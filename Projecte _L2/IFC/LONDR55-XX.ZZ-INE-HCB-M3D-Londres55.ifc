Properties of the parts of a building model (IFC2X3), part 2 of 9

# IfcBuildingElementProxy: ZYR_08.01.01 RACK (Armari Petit):RACK P1 (EXISTENT), ZYR_08.01.01 RACK (Armari Petit):RACK P1 (EXISTENT):753020
ICAT-Identificacio - ICAT_03-Tipus: RACK P1 (EXISTENT); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.03225 m2; ICAT-Volum: 0.136125 m3

# IfcBuildingElementProxy: ZYR_08.01.01 RACK (Armari Petit):RACK P2 (EXISTENT), ZYR_08.01.01 RACK (Armari Petit):RACK P2 (EXISTENT):753062
In: P02 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>, Vidrio
Classification: 50.70.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: RACK P2 (EXISTENT); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RACK P2 (EXISTENT); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.03225 m2; ICAT-Volum: 0.136125 m3

# IfcBuildingElementProxy: ZYR_08.01.01 RACK (Armari Petit):RACK P3 (EXISTENT), ZYR_08.01.01 RACK (Armari Petit):RACK P3 (EXISTENT):753066
In: P03 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>, Vidrio
Classification: 50.70.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: RACK P3 (EXISTENT); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RACK P3 (EXISTENT); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.03225 m2; ICAT-Volum: 0.136125 m3

# IfcBuildingElementProxy: ZYR_08.01.01 RACK (Armari Petit):RACK P4 (EXISTENT), ZYR_08.01.01 RACK (Armari Petit):RACK P4 (EXISTENT):753070
In: P04 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>, Vidrio
Classification: 50.70.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: RACK P4 (EXISTENT); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RACK P4 (EXISTENT); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.03225 m2; ICAT-Volum: 0.136125 m3

# IfcBuildingElementProxy: ZYR_08.01.01 RACK (Armari Petit):RACK P5 (EXISTENT), ZYR_08.01.01 RACK (Armari Petit):RACK P5 (EXISTENT):753074
In: P05 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>, Vidrio
Classification: 50.70.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: RACK P5 (EXISTENT); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RACK P5 (EXISTENT); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.03225 m2; ICAT-Volum: 0.136125 m3

# IfcBuildingElementProxy: ZYR_08.01.01 RACK (Armari Petit):RACK PB (EXISTENT), ZYR_08.01.01 RACK (Armari Petit):RACK PB (EXISTENT):753089
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>, Vidrio
Classification: 50.70.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: RACK PB (EXISTENT); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RACK PB (EXISTENT); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.03225 m2; ICAT-Volum: 0.136125 m3

# IfcBuildingElementProxy: ZYR_08.01.01 RACK (Armari Petit):RACK PS1 (2)
In: PS1 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>, Vidrio
Classification: 50.70.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: RACK PS1; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RACK PS1; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 5.14662 m2; ICAT-Volum: 1.28634 m3
Name (ZYR_08.01.01 RACK (Armari Petit):RACK PS1:...)
753098
753118

# IfcBuildingElementProxy: ZYR_08.01.02 Interfon:01 Interfon Tipus 1 (3)
Type - Material: <Unnamed>
Classification: 50.70.50 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Interfon Tipus 1; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Interfon Tipus 1; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0720617 m2; ICAT-Volum: 0.00061177 m3
Name (ZYR_08.01.02 Interfon:01 Interfon Tipus 1:...) | In
746348 | PS2 - SECTORITZACIÓ I EVACUACIÓ
746376 | PS1 - SECTORITZACIÓ I EVACUACIÓ
747952 | P00 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.01.02 Presa Simple Terra:02 HDMI (7)
Type - Material: <Unnamed>
Classification: 50.70.40.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 02 HDMI; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 02 HDMI; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0149531 m2; ICAT-Volum: 0.0000502326 m3
Name (ZYR_08.01.02 Presa Simple Terra:02 HDMI:...) | In
527819 | P0A - SECTORITZACIÓ I EVACUACIÓ
527860 | P0A - SECTORITZACIÓ I EVACUACIÓ
527975 | P0A - SECTORITZACIÓ I EVACUACIÓ
527985 | P0A - SECTORITZACIÓ I EVACUACIÓ
528130 | P03 - SECTORITZACIÓ I EVACUACIÓ
528335 | P04 - SECTORITZACIÓ I EVACUACIÓ
528462 | P05 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.01.02 Presa Simple:02 TV (4)
Type - Material: <Unnamed>
Classification: 50.70.40.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 02 TV; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 02 TV; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0151511 m2; ICAT-Volum: 0.0000504483 m3
Name (ZYR_08.01.02 Presa Simple:02 TV:...) | In
566434 | P04 - SECTORITZACIÓ I EVACUACIÓ
568509 | P05 - SECTORITZACIÓ I EVACUACIÓ
568559 | P03 - SECTORITZACIÓ I EVACUACIÓ
568592 | P02 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.01.02 Presa Simple:08 HDMI (4)
Type - Material: <Unnamed>
Classification: 50.70.40.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 08 HDMI; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 08 HDMI; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0151511 m2; ICAT-Volum: 0.0000504483 m3
Name (ZYR_08.01.02 Presa Simple:08 HDMI:...) | In
566407 | P04 - SECTORITZACIÓ I EVACUACIÓ
568508 | P05 - SECTORITZACIÓ I EVACUACIÓ
568558 | P03 - SECTORITZACIÓ I EVACUACIÓ
568591 | P02 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.01.02 Videoporter:01 Comunicador Interfon (9)
Type - Material: <Unnamed>
Classification: 50.70.40.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Comunicador Interfon; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Comunicador Interfon; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.19917 m2; ICAT-Volum: 0.00320566 m3
Name (ZYR_08.01.02 Videoporter:01 Comunicador Interfon:...) | In
749879 | P00 - SECTORITZACIÓ I EVACUACIÓ
749969 | P0A - SECTORITZACIÓ I EVACUACIÓ
750143 | Nivel 1
750154 | P02 - SECTORITZACIÓ I EVACUACIÓ
750182 | P03 - SECTORITZACIÓ I EVACUACIÓ
750188 | P04 - SECTORITZACIÓ I EVACUACIÓ
750194 | P05 - SECTORITZACIÓ I EVACUACIÓ
786600 | P02 - SECTORITZACIÓ I EVACUACIÓ
786644 | P03 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.03.01 Camera Domo:01 Camara DOMO 01 (23)
Type - Material: <Unnamed>, Vidrio
Classification: 50.80.20.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Camara DOMO 01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Camara DOMO 01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0210818 m2; ICAT-Volum: 0.000439776 m3
Name (ZYR_08.03.01 Camera Domo:01 Camara DOMO 01:...) | In
600435 | PS2 - SECTORITZACIÓ I EVACUACIÓ
600443 | PS2 - SECTORITZACIÓ I EVACUACIÓ
600460 | PS2 - SECTORITZACIÓ I EVACUACIÓ
600470 | PS1 - SECTORITZACIÓ I EVACUACIÓ
600489 | PS1 - SECTORITZACIÓ I EVACUACIÓ
600512 | PS1 - SECTORITZACIÓ I EVACUACIÓ
600542 | PS1 - SECTORITZACIÓ I EVACUACIÓ
600555 | P00 - SECTORITZACIÓ I EVACUACIÓ
600615 | P00 - SECTORITZACIÓ I EVACUACIÓ
600851 | P0A - SECTORITZACIÓ I EVACUACIÓ
600875 | P0A - SECTORITZACIÓ I EVACUACIÓ
600883 | Nivel 1
600884 | Nivel 1
600966 | P02 - SECTORITZACIÓ I EVACUACIÓ
600967 | P02 - SECTORITZACIÓ I EVACUACIÓ
600969 | P03 - SECTORITZACIÓ I EVACUACIÓ
600970 | P03 - SECTORITZACIÓ I EVACUACIÓ
600977 | P04 - SECTORITZACIÓ I EVACUACIÓ
600978 | P04 - SECTORITZACIÓ I EVACUACIÓ
600980 | P02 - SECTORITZACIÓ I EVACUACIÓ
600989 | P05 - SECTORITZACIÓ I EVACUACIÓ
600990 | P05 - SECTORITZACIÓ I EVACUACIÓ
746410 | PS1 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.03.01 Camera Domo:02 Camara DOMO 02, ZYR_08.03.01 Camera Domo:02 Camara DOMO 02:600571
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>, Vidrio
Classification: 50.80.20.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 02 Camara DOMO 02; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 02 Camara DOMO 02; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0210818 m2; ICAT-Volum: 0.000439776 m3

# IfcBuildingElementProxy: ZYR_08.03.01 Càmera Domo Paret:01 Camara Domo Paret_01 (2)
Type - Material: <Unnamed>, Vidrio
Classification: 50.80.20.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Camara Domo Paret_01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Camara Domo Paret_01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.023385 m2; ICAT-Volum: 0.000424505 m3
Name (ZYR_08.03.01 Càmera Domo Paret:01 Camara Domo Paret_01:...) | In
606844 | Nivel 1
606887 | PsotaC - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.03.02 Centraletes Seguretat:02 CENTRALETA SEG, ZYR_08.03.02 Centraletes Seguretat:02 CENTRALETA SEG:744384
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.80.10.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 02 CENTRALETA SEG; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 02 CENTRALETA SEG; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.11196 m2; ICAT-Volum: 0.000453191 m3

# IfcBuildingElementProxy: ZYR_08.03.03 Contacte Magnetic:01 Detector Magnètic (5)
Type - Material: <Unnamed>
Classification: 50.80.20.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Detector Magnètic; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Detector Magnètic; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0109903 m2; ICAT-Volum: 0.000142487 m3
Name (ZYR_08.03.03 Contacte Magnetic:01 Detector Magnètic:...) | In
744539 | PS2 - SECTORITZACIÓ I EVACUACIÓ
744554 | PS1 - SECTORITZACIÓ I EVACUACIÓ
746560 | P00 - SECTORITZACIÓ I EVACUACIÓ
749996 | Nivel 1
750013 | Nivel 1

# IfcBuildingElementProxy: ZYR_08.03.03 Contacte Magnetic:02 Ventosa (20)
Type - Material: <Unnamed>
Classification: 50.80.20.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 02 Ventosa; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 02 Ventosa; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0109903 m2; ICAT-Volum: 0.000142487 m3
Name (ZYR_08.03.03 Contacte Magnetic:02 Ventosa:...) | In
530172 | PS1 - SECTORITZACIÓ I EVACUACIÓ
530213 | P00 - SECTORITZACIÓ I EVACUACIÓ
530236 | P00 - SECTORITZACIÓ I EVACUACIÓ
530254 | P0A - SECTORITZACIÓ I EVACUACIÓ
530268 | P0A - SECTORITZACIÓ I EVACUACIÓ
530285 | P0A - SECTORITZACIÓ I EVACUACIÓ
530335 | Nivel 1
530352 | Nivel 1
530364 | P02 - SECTORITZACIÓ I EVACUACIÓ
530365 | P02 - SECTORITZACIÓ I EVACUACIÓ
530395 | P03 - SECTORITZACIÓ I EVACUACIÓ
530396 | P03 - SECTORITZACIÓ I EVACUACIÓ
530398 | P04 - SECTORITZACIÓ I EVACUACIÓ
530399 | P04 - SECTORITZACIÓ I EVACUACIÓ
530401 | P05 - SECTORITZACIÓ I EVACUACIÓ
530402 | P05 - SECTORITZACIÓ I EVACUACIÓ
530405 | PS2 - SECTORITZACIÓ I EVACUACIÓ
747921 | P00 - SECTORITZACIÓ I EVACUACIÓ
750198 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
750215 | PsotaC - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.03.03 Controladora de Porta:01 Pany Electric, ZYR_08.03.03 Controladora de Porta:01 Pany Electric:620117
In: PS1 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.80.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Pany Electric; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Pany Electric; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0075 m2; ICAT-Volum: 0.000125 m3

# IfcBuildingElementProxy: ZYR_08.03.03 Detector Volumètric:Detector Volumetric (12)
Type - Material: <Unnamed>
Classification: 50.80.20.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Detector Volumetric; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Detector Volumetric; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.00275476 m2; ICAT-Volum: 0.0000182691 m3
Name (ZYR_08.03.03 Detector Volumètric:Detector Volumetric:...) | In
747873 | P00 - SECTORITZACIÓ I EVACUACIÓ
749962 | P0A - SECTORITZACIÓ I EVACUACIÓ
750025 | Nivel 1
750038 | Nivel 1
750158 | P02 - SECTORITZACIÓ I EVACUACIÓ
750168 | P02 - SECTORITZACIÓ I EVACUACIÓ
750183 | P03 - SECTORITZACIÓ I EVACUACIÓ
750184 | P03 - SECTORITZACIÓ I EVACUACIÓ
750189 | P04 - SECTORITZACIÓ I EVACUACIÓ
750190 | P04 - SECTORITZACIÓ I EVACUACIÓ
750195 | P05 - SECTORITZACIÓ I EVACUACIÓ
750196 | P05 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.03.03 Lector:01 Biometric (16)
Type - Material: <Unnamed>, Vidrio
Classification: 50.80.30.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Biometric; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Biometric; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0790766 m2; ICAT-Volum: 0.00138967 m3
Name (ZYR_08.03.03 Lector:01 Biometric:...) | In
620149 | PS1 - SECTORITZACIÓ I EVACUACIÓ
746459 | P00 - SECTORITZACIÓ I EVACUACIÓ
746505 | P00 - SECTORITZACIÓ I EVACUACIÓ
746525 | P00 - SECTORITZACIÓ I EVACUACIÓ
749889 | P0A - SECTORITZACIÓ I EVACUACIÓ
749922 | P0A - SECTORITZACIÓ I EVACUACIÓ
750048 | Nivel 1
750093 | Nivel 1
750152 | P02 - SECTORITZACIÓ I EVACUACIÓ
750153 | P02 - SECTORITZACIÓ I EVACUACIÓ
750180 | P03 - SECTORITZACIÓ I EVACUACIÓ
750181 | P03 - SECTORITZACIÓ I EVACUACIÓ
750186 | P04 - SECTORITZACIÓ I EVACUACIÓ
750187 | P04 - SECTORITZACIÓ I EVACUACIÓ
750192 | P05 - SECTORITZACIÓ I EVACUACIÓ
750193 | P05 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.04 Altaveu Sostre Encastat:Altaveu Encastat 01 (39)
Type - Material: <Unnamed>, Rejilla
Classification: 50.70.20.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Altaveu Encastat 01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Altaveu Encastat 01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0716347 m2; ICAT-Volum: 0.000929035 m3
Name (ZYR_08.04 Altaveu Sostre Encastat:Altaveu Encastat 01:...) | In
574523 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
574549 | P05 - SECTORITZACIÓ I EVACUACIÓ
574582 | P05 - SECTORITZACIÓ I EVACUACIÓ
574594 | P05 - SECTORITZACIÓ I EVACUACIÓ
574765 | P04 - SECTORITZACIÓ I EVACUACIÓ
574766 | P04 - SECTORITZACIÓ I EVACUACIÓ
574767 | P04 - SECTORITZACIÓ I EVACUACIÓ
574978 | P03 - SECTORITZACIÓ I EVACUACIÓ
574979 | P03 - SECTORITZACIÓ I EVACUACIÓ
574980 | P03 - SECTORITZACIÓ I EVACUACIÓ
575199 | P02 - SECTORITZACIÓ I EVACUACIÓ
575200 | P02 - SECTORITZACIÓ I EVACUACIÓ
575201 | P02 - SECTORITZACIÓ I EVACUACIÓ
575458 | Nivel 1
575459 | Nivel 1
575460 | Nivel 1
575682 | P0A - SECTORITZACIÓ I EVACUACIÓ
575683 | P0A - SECTORITZACIÓ I EVACUACIÓ
575684 | P0A - SECTORITZACIÓ I EVACUACIÓ
575735 | P0A - SECTORITZACIÓ I EVACUACIÓ
575780 | P0A - SECTORITZACIÓ I EVACUACIÓ
575797 | P0A - SECTORITZACIÓ I EVACUACIÓ
575809 | P0A - SECTORITZACIÓ I EVACUACIÓ
575895 | P0A - SECTORITZACIÓ I EVACUACIÓ
575933 | P0A - SECTORITZACIÓ I EVACUACIÓ
575941 | P0A - SECTORITZACIÓ I EVACUACIÓ
576009 | P0A - SECTORITZACIÓ I EVACUACIÓ
576049 | P0A - SECTORITZACIÓ I EVACUACIÓ
576091 | P00 - SECTORITZACIÓ I EVACUACIÓ
576114 | P00 - SECTORITZACIÓ I EVACUACIÓ
576273 | P00 - SECTORITZACIÓ I EVACUACIÓ
576295 | P00 - SECTORITZACIÓ I EVACUACIÓ
576327 | P00 - SECTORITZACIÓ I EVACUACIÓ
576349 | P00 - SECTORITZACIÓ I EVACUACIÓ
576368 | P00 - SECTORITZACIÓ I EVACUACIÓ
576408 | P00 - SECTORITZACIÓ I EVACUACIÓ
576422 | P00 - SECTORITZACIÓ I EVACUACIÓ
576584 | PS1 - SECTORITZACIÓ I EVACUACIÓ
576624 | PS1 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.04 Altaveu Sostre Encastat:Altaveu Encastat 08 (Rect) (79)
Type - Material: <Unnamed>, Rejilla
Classification: 50.70.20.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Altaveu Encastat 08 (Rect); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Altaveu Encastat 08 (Rect); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0716347 m2; ICAT-Volum: 0.000929035 m3
Name (ZYR_08.04 Altaveu Sostre Encastat:Altaveu Encastat 08 (Rect):...) | In
574623 | P05 - SECTORITZACIÓ I EVACUACIÓ
574641 | P05 - SECTORITZACIÓ I EVACUACIÓ
574655 | P05 - SECTORITZACIÓ I EVACUACIÓ
574671 | P05 - SECTORITZACIÓ I EVACUACIÓ
574691 | P05 - SECTORITZACIÓ I EVACUACIÓ
574699 | P05 - SECTORITZACIÓ I EVACUACIÓ
574719 | P05 - SECTORITZACIÓ I EVACUACIÓ
574720 | P05 - SECTORITZACIÓ I EVACUACIÓ
574721 | P05 - SECTORITZACIÓ I EVACUACIÓ
574738 | P05 - SECTORITZACIÓ I EVACUACIÓ
574755 | P05 - SECTORITZACIÓ I EVACUACIÓ
574786 | P04 - SECTORITZACIÓ I EVACUACIÓ
574807 | P04 - SECTORITZACIÓ I EVACUACIÓ
574825 | P04 - SECTORITZACIÓ I EVACUACIÓ
574878 | P04 - SECTORITZACIÓ I EVACUACIÓ
574886 | P04 - SECTORITZACIÓ I EVACUACIÓ
574902 | P04 - SECTORITZACIÓ I EVACUACIÓ
574910 | P04 - SECTORITZACIÓ I EVACUACIÓ
574932 | P04 - SECTORITZACIÓ I EVACUACIÓ
574947 | P04 - SECTORITZACIÓ I EVACUACIÓ
574948 | P04 - SECTORITZACIÓ I EVACUACIÓ
574949 | P04 - SECTORITZACIÓ I EVACUACIÓ
574972 | P04 - SECTORITZACIÓ I EVACUACIÓ
574990 | P03 - SECTORITZACIÓ I EVACUACIÓ
575010 | P03 - SECTORITZACIÓ I EVACUACIÓ
575028 | P03 - SECTORITZACIÓ I EVACUACIÓ
575044 | P03 - SECTORITZACIÓ I EVACUACIÓ
575072 | P03 - SECTORITZACIÓ I EVACUACIÓ
575086 | P03 - SECTORITZACIÓ I EVACUACIÓ
575122 | P03 - SECTORITZACIÓ I EVACUACIÓ
575138 | P03 - SECTORITZACIÓ I EVACUACIÓ
575157 | P03 - SECTORITZACIÓ I EVACUACIÓ
575193 | P03 - SECTORITZACIÓ I EVACUACIÓ
575202 | P02 - SECTORITZACIÓ I EVACUACIÓ
575214 | P03 - SECTORITZACIÓ I EVACUACIÓ
575222 | P03 - SECTORITZACIÓ I EVACUACIÓ
575230 | P03 - SECTORITZACIÓ I EVACUACIÓ
575247 | P02 - SECTORITZACIÓ I EVACUACIÓ
575283 | P02 - SECTORITZACIÓ I EVACUACIÓ
575302 | P02 - SECTORITZACIÓ I EVACUACIÓ
575303 | P02 - SECTORITZACIÓ I EVACUACIÓ
575321 | P02 - SECTORITZACIÓ I EVACUACIÓ
575331 | P02 - SECTORITZACIÓ I EVACUACIÓ
575345 | P02 - SECTORITZACIÓ I EVACUACIÓ
575366 | P02 - SECTORITZACIÓ I EVACUACIÓ
575384 | P02 - SECTORITZACIÓ I EVACUACIÓ
575402 | P02 - SECTORITZACIÓ I EVACUACIÓ
575426 | P02 - SECTORITZACIÓ I EVACUACIÓ
575434 | P02 - SECTORITZACIÓ I EVACUACIÓ
575450 | P02 - SECTORITZACIÓ I EVACUACIÓ
575470 | Nivel 1
575483 | Nivel 1
575491 | Nivel 1
575503 | Nivel 1
575513 | Nivel 1
575525 | Nivel 1
575533 | Nivel 1
575543 | Nivel 1
575553 | Nivel 1
575567 | Nivel 1
575577 | Nivel 1
575589 | Nivel 1
575608 | Nivel 1
575618 | Nivel 1
575626 | Nivel 1
575648 | Nivel 1
575658 | Nivel 1
575672 | Nivel 1
576126 | P00 - SECTORITZACIÓ I EVACUACIÓ
576174 | P00 - SECTORITZACIÓ I EVACUACIÓ
576186 | P00 - SECTORITZACIÓ I EVACUACIÓ
576254 | P00 - SECTORITZACIÓ I EVACUACIÓ
576440 | P00 - SECTORITZACIÓ I EVACUACIÓ
576474 | P00 - SECTORITZACIÓ I EVACUACIÓ
576558 | P00 - SECTORITZACIÓ I EVACUACIÓ
576574 | P00 - SECTORITZACIÓ I EVACUACIÓ
576635 | PS2 - SECTORITZACIÓ I EVACUACIÓ
576636 | PS2 - SECTORITZACIÓ I EVACUACIÓ
576688 | PS2 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.05 Indicador Optic Sostre:01 Detector Optic 01 (8)
Type - Material: <Unnamed>, Vidrio
Classification: 50.70.50.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Detector Optic 01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Detector Optic 01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.03 m2; ICAT-Volum: 0.0005049 m3
Name (ZYR_08.05 Indicador Optic Sostre:01 Detector Optic 01:...) | In
525889 | P02 - SECTORITZACIÓ I EVACUACIÓ
525909 | P03 - SECTORITZACIÓ I EVACUACIÓ
525912 | P04 - SECTORITZACIÓ I EVACUACIÓ
525915 | P05 - SECTORITZACIÓ I EVACUACIÓ
525918 | Nivel 1
525921 | P0A - SECTORITZACIÓ I EVACUACIÓ
525943 | P00 - SECTORITZACIÓ I EVACUACIÓ
525951 | P00 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.05 Tirador Alarma:01 Tirador Alarma (8)
Type - Material: <Unnamed>
Classification: 50.70.50.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Tirador Alarma; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Tirador Alarma; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0220588 m2; ICAT-Volum: 0.000239746 m3
Name (ZYR_08.05 Tirador Alarma:01 Tirador Alarma:...) | In
522946 | P02 - SECTORITZACIÓ I EVACUACIÓ
525908 | P03 - SECTORITZACIÓ I EVACUACIÓ
525911 | P04 - SECTORITZACIÓ I EVACUACIÓ
525914 | P05 - SECTORITZACIÓ I EVACUACIÓ
525917 | Nivel 1
525920 | P0A - SECTORITZACIÓ I EVACUACIÓ
525942 | P00 - SECTORITZACIÓ I EVACUACIÓ
525967 | P00 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_12.01.03 BIE:BIE (15)
Type - Material: NLRS_x_rgb 255 255 255 T00 wit_generiek, NLRS_x_rgb 255 000 000 T00 rood_generiek, Steel, <Unnamed>
Classification: 50.50.10.70 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: BIE; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: BIE; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.707268 m2; ICAT-Volum: 0.086838 m3
Name (ZYR_12.01.03 BIE:BIE:...) | In
631307 | PS1 - SECTORITZACIÓ I EVACUACIÓ
631449 | P00 - SECTORITZACIÓ I EVACUACIÓ
631603 | P00 - SECTORITZACIÓ I EVACUACIÓ
631748 | P00 - SECTORITZACIÓ I EVACUACIÓ
632190 | Nivel 1
632261 | Nivel 1
632477 | P02 - SECTORITZACIÓ I EVACUACIÓ
632489 | P02 - SECTORITZACIÓ I EVACUACIÓ
632530 | P03 - SECTORITZACIÓ I EVACUACIÓ
632534 | P03 - SECTORITZACIÓ I EVACUACIÓ
632566 | P04 - SECTORITZACIÓ I EVACUACIÓ
632570 | P04 - SECTORITZACIÓ I EVACUACIÓ
632688 | P05 - SECTORITZACIÓ I EVACUACIÓ
632692 | P05 - SECTORITZACIÓ I EVACUACIÓ
701002 | PS1 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_15.03 Unió Rect Conducte:ZYR_15.03 Unió Rect Conducte (5)
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: ZYR_15.03 Unió Rect Conducte; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: ZYR_15.03 Unió Rect Conducte; ICAT_04-EstatusObra: Nueva construcción
Name (ZYR_15.03 Unió Rect Conducte:ZYR_15.03 Unió Rect Conducte:...) | In | ICAT-Superficie (m2) | ICAT-Volum (m3) | Group
437482 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.17925 | 0.000875 | Mecánica Aire Aportació PK 1; Mecánica Aire Aportació PK EI 1
806301 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.3435 | 0.0016875 | ASP 4
807234 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.39625 | 0.00195 | ASP 3
808094 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.3435 | 0.0016875 | ASP 3
808159 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.0003 | ASP 3

# IfcCovering: Aislamiento de conducto:Por defecto, Aislamiento de conducto:Por defecto:776339
In: P04 - SECTORITZACIÓ I EVACUACIÓ
Type - PredefinedType: INSULATION
Pset_CoveringCommon - Reference: Por defecto; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Por defecto; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Llarg: 2.5164 m; ICAT-Superficie: 3.27132 m2; ICAT-Volum: 0.0817829 m3

# IfcDistributionControlElement: ZYR_12.01.02 Extintor:01 Extintor Pols_ABC (26)
Type - Material: Paint_Red Glossy_ Fire Extinguisher, Steel, Copper, Plastic, Opaque Black, <Unnamed>, Steel, Paint Finish, Ivory, Glossy
Classification: 50.50.10.80 (Uniformat)
Pset_QuantityTakeOff - Reference: 01 Extintor Pols_ABC
ICAT-Identificacio - ICAT_03-Tipus: 01 Extintor Pols_ABC; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.05498 m2; ICAT-Volum: 0.0133775 m3
Name (ZYR_12.01.02 Extintor:01 Extintor Pols_ABC:...) | In
623528 | PS2 - SECTORITZACIÓ I EVACUACIÓ
628439 | PS1 - SECTORITZACIÓ I EVACUACIÓ
628487 | PS1 - SECTORITZACIÓ I EVACUACIÓ
628559 | PS1 - SECTORITZACIÓ I EVACUACIÓ
628575 | PS1 - SECTORITZACIÓ I EVACUACIÓ
628646 | PS1 - SECTORITZACIÓ I EVACUACIÓ
631411 | P00 - SECTORITZACIÓ I EVACUACIÓ
631532 | P00 - SECTORITZACIÓ I EVACUACIÓ
631715 | P00 - SECTORITZACIÓ I EVACUACIÓ
631835 | P00 - SECTORITZACIÓ I EVACUACIÓ
631878 | P00 - SECTORITZACIÓ I EVACUACIÓ
631959 | P0A - SECTORITZACIÓ I EVACUACIÓ
632144 | Nivel 1
632455 | Nivel 1
632483 | P02 - SECTORITZACIÓ I EVACUACIÓ
632523 | P02 - SECTORITZACIÓ I EVACUACIÓ
632533 | P03 - SECTORITZACIÓ I EVACUACIÓ
632535 | P03 - SECTORITZACIÓ I EVACUACIÓ
632569 | P04 - SECTORITZACIÓ I EVACUACIÓ
632571 | P04 - SECTORITZACIÓ I EVACUACIÓ
632691 | P05 - SECTORITZACIÓ I EVACUACIÓ
632693 | P05 - SECTORITZACIÓ I EVACUACIÓ
632704 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
632723 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
632769 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
701220 | PS1 - SECTORITZACIÓ I EVACUACIÓ

# IfcDistributionControlElement: ZYR_12.01.02 Extintor:02 Extintor CO2 (8)
Type - Material: Paint_Red Glossy_ Fire Extinguisher, Steel, Copper, Plastic, Opaque Black, <Unnamed>, Steel, Paint Finish, Ivory, Glossy
Classification: 50.50.10.80 (Uniformat)
Pset_QuantityTakeOff - Reference: 02 Extintor CO2
ICAT-Identificacio - ICAT_03-Tipus: 02 Extintor CO2; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.05498 m2; ICAT-Volum: 0.0133775 m3
Name (ZYR_12.01.02 Extintor:02 Extintor CO2:...) | In
628701 | PS1 - SECTORITZACIÓ I EVACUACIÓ
631783 | P00 - SECTORITZACIÓ I EVACUACIÓ
632463 | Nivel 1
632524 | P02 - SECTORITZACIÓ I EVACUACIÓ
632536 | P03 - SECTORITZACIÓ I EVACUACIÓ
632572 | P04 - SECTORITZACIÓ I EVACUACIÓ
632694 | P05 - SECTORITZACIÓ I EVACUACIÓ
701153 | PS1 - SECTORITZACIÓ I EVACUACIÓ

# IfcDistributionControlElement: ZYR_12.01.06 Sirena Paret:01 Sirena Interior Tipus 1 (14)
Type - Material: Vidrio, Rojo
Classification: 50.50.10.40 (Uniformat); Material: Rojo, Vidrio, <Unnamed>
Pset_QuantityTakeOff - Reference: 01 Sirena Interior Tipus 1
ICAT-Identificacio - ICAT_03-Tipus: 01 Sirena Interior Tipus 1; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0828114 m2; ICAT-Volum: 0.000668565 m3
Name (ZYR_12.01.06 Sirena Paret:01 Sirena Interior Tipus 1:...) | In
626209 | PS2 - SECTORITZACIÓ I EVACUACIÓ
628440 | PS1 - SECTORITZACIÓ I EVACUACIÓ
628644 | PS1 - SECTORITZACIÓ I EVACUACIÓ
631409 | P00 - SECTORITZACIÓ I EVACUACIÓ
631517 | P00 - SECTORITZACIÓ I EVACUACIÓ
631713 | P00 - SECTORITZACIÓ I EVACUACIÓ
631957 | P0A - SECTORITZACIÓ I EVACUACIÓ
632142 | Nivel 1
632481 | P02 - SECTORITZACIÓ I EVACUACIÓ
632531 | P03 - SECTORITZACIÓ I EVACUACIÓ
632567 | P04 - SECTORITZACIÓ I EVACUACIÓ
632689 | P05 - SECTORITZACIÓ I EVACUACIÓ
632767 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
701151 | PS1 - SECTORITZACIÓ I EVACUACIÓ

# IfcDistributionControlElement: ZYR_12.01.07 Centraletes CO - DET - CI:02 CENTRALETA CI (2)
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.90.10.10 (Uniformat)
Pset_QuantityTakeOff - Reference: 02 CENTRALETA CI
ICAT-Identificacio - ICAT_03-Tipus: 02 CENTRALETA CI; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.11196 m2; ICAT-Volum: 0.000453191 m3
Name (ZYR_12.01.07 Centraletes CO - DET - CI:02 CENTRALETA CI:...)
741786
741893

# IfcDistributionControlElement: ZYR_12.01.08 Detectors:01 Detector Òptic (156)
Type - Material: <Unnamed>
Classification: 50.50.20.20 (Uniformat)
Pset_QuantityTakeOff - Reference: 01 Detector Òptic
ICAT-Identificacio - ICAT_03-Tipus: 01 Detector Òptic; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0138955 m2; ICAT-Volum: 0.000316204 m3
Name (ZYR_12.01.08 Detectors:01 Detector Òptic:...) | In
539646 | PS2 - SECTORITZACIÓ I EVACUACIÓ
539769 | PS2 - SECTORITZACIÓ I EVACUACIÓ
539787 | PS2 - SECTORITZACIÓ I EVACUACIÓ
539836 | PS1 - SECTORITZACIÓ I EVACUACIÓ
539854 | PS1 - SECTORITZACIÓ I EVACUACIÓ
539923 | PS1 - SECTORITZACIÓ I EVACUACIÓ
539935 | PS1 - SECTORITZACIÓ I EVACUACIÓ
539945 | PS1 - SECTORITZACIÓ I EVACUACIÓ
539957 | PS1 - SECTORITZACIÓ I EVACUACIÓ
539967 | PS1 - SECTORITZACIÓ I EVACUACIÓ
539977 | PS1 - SECTORITZACIÓ I EVACUACIÓ
539987 | PS1 - SECTORITZACIÓ I EVACUACIÓ
539997 | PS1 - SECTORITZACIÓ I EVACUACIÓ
540005 | PS1 - SECTORITZACIÓ I EVACUACIÓ
540013 | PS1 - SECTORITZACIÓ I EVACUACIÓ
540021 | PS1 - SECTORITZACIÓ I EVACUACIÓ
540043 | P00 - SECTORITZACIÓ I EVACUACIÓ
540118 | P00 - SECTORITZACIÓ I EVACUACIÓ
540128 | P00 - SECTORITZACIÓ I EVACUACIÓ
540138 | P00 - SECTORITZACIÓ I EVACUACIÓ
540150 | P00 - SECTORITZACIÓ I EVACUACIÓ
540162 | P00 - SECTORITZACIÓ I EVACUACIÓ
540172 | P00 - SECTORITZACIÓ I EVACUACIÓ
540180 | P00 - SECTORITZACIÓ I EVACUACIÓ
540190 | P00 - SECTORITZACIÓ I EVACUACIÓ
540198 | P00 - SECTORITZACIÓ I EVACUACIÓ
540206 | P00 - SECTORITZACIÓ I EVACUACIÓ
540214 | P00 - SECTORITZACIÓ I EVACUACIÓ
540228 | P00 - SECTORITZACIÓ I EVACUACIÓ
540238 | P00 - SECTORITZACIÓ I EVACUACIÓ
540246 | P00 - SECTORITZACIÓ I EVACUACIÓ
540311 | P00 - SECTORITZACIÓ I EVACUACIÓ
540339 | P00 - SECTORITZACIÓ I EVACUACIÓ
540349 | P00 - SECTORITZACIÓ I EVACUACIÓ
540434 | P0A - SECTORITZACIÓ I EVACUACIÓ
540485 | P0A - SECTORITZACIÓ I EVACUACIÓ
540493 | P0A - SECTORITZACIÓ I EVACUACIÓ
540523 | P0A - SECTORITZACIÓ I EVACUACIÓ
540599 | P0A - SECTORITZACIÓ I EVACUACIÓ
540707 | P0A - SECTORITZACIÓ I EVACUACIÓ
540883 | P0A - SECTORITZACIÓ I EVACUACIÓ
541131 | P0A - SECTORITZACIÓ I EVACUACIÓ
541258 | P0A - SECTORITZACIÓ I EVACUACIÓ
541266 | P0A - SECTORITZACIÓ I EVACUACIÓ
541308 | Nivel 1
541326 | Nivel 1
541334 | Nivel 1
541358 | Nivel 1
541376 | Nivel 1
541392 | Nivel 1
541414 | Nivel 1
541422 | Nivel 1
541432 | Nivel 1
541442 | Nivel 1
541452 | Nivel 1
541462 | Nivel 1
541476 | Nivel 1
541482 | Nivel 1
541513 | Nivel 1
541531 | Nivel 1
541539 | Nivel 1
541574 | Nivel 1
541584 | Nivel 1
541690 | Nivel 1
541709 | Nivel 1
541726 | Nivel 1
541745 | Nivel 1
541762 | Nivel 1
541794 | Nivel 1
541810 | Nivel 1
541826 | Nivel 1
541846 | Nivel 1
541854 | Nivel 1
541870 | P02 - SECTORITZACIÓ I EVACUACIÓ
541871 | P02 - SECTORITZACIÓ I EVACUACIÓ
541872 | P02 - SECTORITZACIÓ I EVACUACIÓ
541873 | P02 - SECTORITZACIÓ I EVACUACIÓ
541874 | P02 - SECTORITZACIÓ I EVACUACIÓ
541875 | P02 - SECTORITZACIÓ I EVACUACIÓ
541900 | P02 - SECTORITZACIÓ I EVACUACIÓ
541922 | P02 - SECTORITZACIÓ I EVACUACIÓ
541949 | P02 - SECTORITZACIÓ I EVACUACIÓ
541965 | P02 - SECTORITZACIÓ I EVACUACIÓ
541975 | P02 - SECTORITZACIÓ I EVACUACIÓ
541991 | P02 - SECTORITZACIÓ I EVACUACIÓ
542005 | P02 - SECTORITZACIÓ I EVACUACIÓ
542048 | P02 - SECTORITZACIÓ I EVACUACIÓ
542058 | P02 - SECTORITZACIÓ I EVACUACIÓ
542070 | P02 - SECTORITZACIÓ I EVACUACIÓ
542078 | P02 - SECTORITZACIÓ I EVACUACIÓ
542092 | P02 - SECTORITZACIÓ I EVACUACIÓ
542157 | P02 - SECTORITZACIÓ I EVACUACIÓ
542167 | P02 - SECTORITZACIÓ I EVACUACIÓ
542213 | P02 - SECTORITZACIÓ I EVACUACIÓ
542228 | P02 - SECTORITZACIÓ I EVACUACIÓ
542250 | P02 - SECTORITZACIÓ I EVACUACIÓ
542262 | P03 - SECTORITZACIÓ I EVACUACIÓ
542263 | P03 - SECTORITZACIÓ I EVACUACIÓ
542264 | P03 - SECTORITZACIÓ I EVACUACIÓ
542265 | P03 - SECTORITZACIÓ I EVACUACIÓ
542266 | P03 - SECTORITZACIÓ I EVACUACIÓ
542267 | P03 - SECTORITZACIÓ I EVACUACIÓ
542297 | P03 - SECTORITZACIÓ I EVACUACIÓ
542321 | P03 - SECTORITZACIÓ I EVACUACIÓ
542339 | P03 - SECTORITZACIÓ I EVACUACIÓ
542347 | P03 - SECTORITZACIÓ I EVACUACIÓ
542357 | P03 - SECTORITZACIÓ I EVACUACIÓ
542388 | P03 - SECTORITZACIÓ I EVACUACIÓ
542405 | P03 - SECTORITZACIÓ I EVACUACIÓ
542423 | P03 - SECTORITZACIÓ I EVACUACIÓ
542431 | P03 - SECTORITZACIÓ I EVACUACIÓ
542456 | P03 - SECTORITZACIÓ I EVACUACIÓ
542488 | P03 - SECTORITZACIÓ I EVACUACIÓ
542496 | P03 - SECTORITZACIÓ I EVACUACIÓ
542508 | P04 - SECTORITZACIÓ I EVACUACIÓ
542509 | P04 - SECTORITZACIÓ I EVACUACIÓ
542510 | P04 - SECTORITZACIÓ I EVACUACIÓ
542511 | P04 - SECTORITZACIÓ I EVACUACIÓ
542512 | P04 - SECTORITZACIÓ I EVACUACIÓ
542513 | P04 - SECTORITZACIÓ I EVACUACIÓ
542514 | P04 - SECTORITZACIÓ I EVACUACIÓ
542531 | P04 - SECTORITZACIÓ I EVACUACIÓ
542556 | P04 - SECTORITZACIÓ I EVACUACIÓ
542568 | P04 - SECTORITZACIÓ I EVACUACIÓ
542600 | P04 - SECTORITZACIÓ I EVACUACIÓ
542620 | P04 - SECTORITZACIÓ I EVACUACIÓ
542638 | P04 - SECTORITZACIÓ I EVACUACIÓ
542648 | P04 - SECTORITZACIÓ I EVACUACIÓ
542666 | P05 - SECTORITZACIÓ I EVACUACIÓ
542667 | P05 - SECTORITZACIÓ I EVACUACIÓ
542668 | P05 - SECTORITZACIÓ I EVACUACIÓ
542669 | P05 - SECTORITZACIÓ I EVACUACIÓ
542670 | P05 - SECTORITZACIÓ I EVACUACIÓ
542671 | P05 - SECTORITZACIÓ I EVACUACIÓ
542684 | P05 - SECTORITZACIÓ I EVACUACIÓ
542711 | P05 - SECTORITZACIÓ I EVACUACIÓ
542719 | P05 - SECTORITZACIÓ I EVACUACIÓ
542735 | P05 - SECTORITZACIÓ I EVACUACIÓ
542751 | P05 - SECTORITZACIÓ I EVACUACIÓ
542769 | P05 - SECTORITZACIÓ I EVACUACIÓ
542785 | P05 - SECTORITZACIÓ I EVACUACIÓ
542799 | P05 - SECTORITZACIÓ I EVACUACIÓ
542807 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
542808 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
542810 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
542811 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
558506 | P04 - SECTORITZACIÓ I EVACUACIÓ
561557 | P05 - SECTORITZACIÓ I EVACUACIÓ
596998 | P04 - SECTORITZACIÓ I EVACUACIÓ
631911 | P00 - SECTORITZACIÓ I EVACUACIÓ
631956 | P0A - SECTORITZACIÓ I EVACUACIÓ
679244 | P00 - SECTORITZACIÓ I EVACUACIÓ
700886 | PS1 - SECTORITZACIÓ I EVACUACIÓ
700894 | PS1 - SECTORITZACIÓ I EVACUACIÓ
700939 | PS1 - SECTORITZACIÓ I EVACUACIÓ
700940 | PS1 - SECTORITZACIÓ I EVACUACIÓ

# IfcDistributionControlElement: ZYR_12.01.08 Detectors:03 Detector CO (2)
In: PS1 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.50.20.20 (Uniformat)
Pset_QuantityTakeOff - Reference: 03 Detector CO
ICAT-Identificacio - ICAT_03-Tipus: 03 Detector CO; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0631221 m2; ICAT-Volum: 0.00261718 m3
Name (ZYR_12.01.08 Detectors:03 Detector CO:...)
700961
700981

# IfcDistributionControlElement: ZYR_12.01.08 Polsadors:01 Polsador Emergència (14)
Type - Material: Vermell, Vidrio
Classification: 50.50.30.10 (Uniformat)
Pset_QuantityTakeOff - Reference: 01 Polsador Emergència
ICAT-Identificacio - ICAT_03-Tipus: 01 Polsador Emergència; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0284518 m2; ICAT-Volum: 0.000231045 m3
Name (ZYR_12.01.08 Polsadors:01 Polsador Emergència:...) | In
628355 | PS2 - SECTORITZACIÓ I EVACUACIÓ
628441 | PS1 - SECTORITZACIÓ I EVACUACIÓ
628645 | PS1 - SECTORITZACIÓ I EVACUACIÓ
631410 | P00 - SECTORITZACIÓ I EVACUACIÓ
631518 | P00 - SECTORITZACIÓ I EVACUACIÓ
631714 | P00 - SECTORITZACIÓ I EVACUACIÓ
631958 | P0A - SECTORITZACIÓ I EVACUACIÓ
632143 | Nivel 1
632482 | P02 - SECTORITZACIÓ I EVACUACIÓ
632532 | P03 - SECTORITZACIÓ I EVACUACIÓ
632568 | P04 - SECTORITZACIÓ I EVACUACIÓ
632690 | P05 - SECTORITZACIÓ I EVACUACIÓ
632768 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
701152 | PS1 - SECTORITZACIÓ I EVACUACIÓ

# IfcDistributionControlElement: ZYR_12.01.08 Retenidor Electromagnètic:ZYR_12.01.08 Retenidor Electromagnètic (40)
Type - Material: <Unnamed>
Classification: 50.50.40.50 (Uniformat)
Pset_QuantityTakeOff - Reference: ZYR_12.01.08 Retenidor Electromagnètic
ICAT-Identificacio - ICAT_03-Tipus: ZYR_12.01.08 Retenidor Electromagnètic; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0093 m2; ICAT-Volum: 0.00009 m3
Name (ZYR_12.01.08 Retenidor Electromagnètic:ZYR_12.01.08 Retenidor Electromagnètic:...) | In
531703 | PS2 - SECTORITZACIÓ I EVACUACIÓ
531726 | PS2 - SECTORITZACIÓ I EVACUACIÓ
531734 | PS2 - SECTORITZACIÓ I EVACUACIÓ
531746 | PS2 - SECTORITZACIÓ I EVACUACIÓ
531756 | PS2 - SECTORITZACIÓ I EVACUACIÓ
531764 | PS2 - SECTORITZACIÓ I EVACUACIÓ
531803 | PS1 - SECTORITZACIÓ I EVACUACIÓ
531811 | PS1 - SECTORITZACIÓ I EVACUACIÓ
531829 | PS1 - SECTORITZACIÓ I EVACUACIÓ
531839 | PS1 - SECTORITZACIÓ I EVACUACIÓ
531847 | PS1 - SECTORITZACIÓ I EVACUACIÓ
531855 | PS1 - SECTORITZACIÓ I EVACUACIÓ
531879 | PS1 - SECTORITZACIÓ I EVACUACIÓ
531887 | PS1 - SECTORITZACIÓ I EVACUACIÓ
531922 | P0A - SECTORITZACIÓ I EVACUACIÓ
531948 | P00 - SECTORITZACIÓ I EVACUACIÓ
531972 | P00 - SECTORITZACIÓ I EVACUACIÓ
531988 | P00 - SECTORITZACIÓ I EVACUACIÓ
532006 | P00 - SECTORITZACIÓ I EVACUACIÓ
532014 | P00 - SECTORITZACIÓ I EVACUACIÓ
532022 | P00 - SECTORITZACIÓ I EVACUACIÓ
532030 | P00 - SECTORITZACIÓ I EVACUACIÓ
532054 | P02 - SECTORITZACIÓ I EVACUACIÓ
532055 | P02 - SECTORITZACIÓ I EVACUACIÓ
532066 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
532067 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
532077 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
532085 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
568722 | P00 - SECTORITZACIÓ I EVACUACIÓ
631979 | P0A - SECTORITZACIÓ I EVACUACIÓ
632032 | P0A - SECTORITZACIÓ I EVACUACIÓ
632046 | P0A - SECTORITZACIÓ I EVACUACIÓ
632385 | Nivel 1
632434 | Nivel 1
632679 | P03 - SECTORITZACIÓ I EVACUACIÓ
632680 | P03 - SECTORITZACIÓ I EVACUACIÓ
632682 | P04 - SECTORITZACIÓ I EVACUACIÓ
632683 | P04 - SECTORITZACIÓ I EVACUACIÓ
632685 | P05 - SECTORITZACIÓ I EVACUACIÓ
632686 | P05 - SECTORITZACIÓ I EVACUACIÓ

# IfcDistributionPort (4648)
Description: Flow
Name | FlowDirection | Group
InPort_352104_3 | SINK | AI 1
OutPort_345767_0 | SOURCE | AI 1
InPort_345767_1 | SINK | AI 1
OutPort_355542_1 | SOURCE | AI 1
InPort_350785_0 | SINK | AI 1
OutPort_351253_2 | SOURCE | AI 1
InPort_355818_1 | SINK | AI 1
OutPort_350785_1 | SOURCE | AI 1
InPort_350796_0 | SINK | AI 1
InPort_351672_1 | SINK | AI 1
OutPort_350796_1 | SOURCE | AI 1
InPort_351025_0 | SINK | AI 1
OutPort_351349_2 | SOURCE | AI 1
InPort_351363_2 | SINK | AI 1
OutPort_351025_1 | SOURCE | AI 1
InPort_351253_1 | SINK | AI 1
OutPort_351037_1 | SOURCE | AI 1
InPort_351037_2 | SINK | AI 1
OutPort_351232_1 | SOURCE | AI 1
InPort_351284_1 | SINK | AI 1
OutPort_351037_3 | SOURCE | AI 1
InPort_351232_2 | SINK | AI 1
OutPort_351038_0 | SOURCE | AI 1
InPort_351038_1 | SINK | AI 1
OutPort_355312_2 | SOURCE | AI 1
InPort_351160_0 | SINK | AI 1
OutPort_351674_2 | SOURCE | AI 1
InPort_355312_1 | SINK | AI 1
OutPort_351160_1 | SOURCE | AI 1
InPort_351300_0 | SINK | AI 1
OutPort_351284_2 | SOURCE | AI 1
InPort_351287_0 | SINK | AI 1
OutPort_351299_3 | SOURCE | AI 1
InPort_356437_1 | SINK | AI 1
OutPort_351287_1 | SOURCE | AI 1
InPort_351299_1 | SINK | AI 1
OutPort_351300_1 | SOURCE | AI 1
InPort_351349_1 | SINK | AI 1
OutPort_351299_2 | SOURCE | AI 1
InPort_351352_0 | SINK | AI 1
OutPort_351363_1 | SOURCE | AI 1
InPort_574840_1 | SINK | AI 1
OutPort_351352_1 | SOURCE | AI 1
InPort_351569_0 | SINK | AI 1
OutPort_351816_2 | SOURCE | AI 1
InPort_351839_2 | SINK | AI 1
OutPort_351569_1 | SOURCE | AI 1
InPort_355366_0 | SINK | AI 1
OutPort_351672_2 | SOURCE | AI 1
InPort_351674_1 | SINK | AI 1
OutPort_351672_3 | SOURCE | AI 1
InPort_351716_1 | SINK | AI 1
OutPort_351672_4 | SOURCE | AI 1
InPort_351770_0 | SINK | AI 1
OutPort_351716_2 | SOURCE | AI 1
InPort_351816_1 | SINK | AI 1
OutPort_351770_1 | SOURCE | AI 1
InPort_351832_0 | SINK | AI 1
OutPort_351839_1 | SOURCE | AI 1
InPort_757644_1 | SINK | AI 1
OutPort_351832_1 | SOURCE | AI 1
InPort_352075_0 | SINK | AI 1
OutPort_352113_2 | SOURCE | AI 1
InPort_352229_1 | SINK | AI 1
OutPort_352075_1 | SOURCE | AI 1
InPort_352113_1 | SINK | AI 1
OutPort_352104_1 | SOURCE | AI 1
InPort_352169_1 | SINK | AI 1
OutPort_352104_2 | SOURCE | AI 1
InPort_352131_0 | SINK | AI 1
OutPort_352169_2 | SOURCE | AI 1
InPort_352406_1 | SINK | AI 1
OutPort_352131_1 | SOURCE | AI 1
InPort_352191_0 | SINK | AI 1
OutPort_352229_2 | SOURCE | AI 1
InPort_356009_1 | SINK | AI 1
OutPort_352191_1 | SOURCE | AI 1
InPort_352372_0 | SINK | AI 1
OutPort_352406_2 | SOURCE | AI 1
InPort_755324_1 | SINK | AI 1
OutPort_352372_1 | SOURCE | AI 1
InPort_354825_1 | SINK | AI 2
InPort_355542_2 | SINK | AI 1
OutPort_355366_1 | SOURCE | AI 1
InPort_355793_1 | SINK | AI 4
InPort_355803_1 | SINK | AI 3
InPort_355901_1 | SINK | AI 5
InPort_355909_1 | SINK | AI 6
InPort_355940_1 | SINK | AI 9
InPort_355941_1 | SINK | AI 10
InPort_355942_1 | SINK | AI 8
InPort_355943_1 | SINK | AI 7
InPort_355967_1 | SINK | AI 11
InPort_356420_1 | SINK | AI 12
InPort_356611_1 | SINK | AI 13
InPort_356632_1 | SINK | AI 14
InPort_356642_1 | SINK | AI 15
InPort_356805_1 | SINK | AI 17
InPort_356828_1 | SINK | AI 16
InPort_358681_1 | SINK | ASP 2
OutPort_395321_0 | SOURCE | ASP 2
InPort_362103_1 | SINK | ASP 1
OutPort_362116_0 | SOURCE | ASP 1
InPort_362116_1 | SINK | ASP 1
OutPort_397359_1 | SOURCE | ASP 1
InPort_364068_1 | SINK | ASP 1
OutPort_398051_0 | SOURCE | ASP 1
InPort_382162_0 | SINK | ASP 2
OutPort_395778_1 | SOURCE | ASP 2
InPort_395892_2 | SINK | ASP 2
OutPort_382162_1 | SOURCE | ASP 2
InPort_383258_0 | SINK | ASP 1
OutPort_398315_2 | SOURCE | ASP 1
InPort_398446_1 | SINK | ASP 1
OutPort_383258_1 | SOURCE | ASP 1
InPort_383372_1 | SINK | ASP 1
OutPort_398428_1 | SOURCE | ASP 1
InPort_395321_0 | SINK | ASP 2
OutPort_358681_1 | SOURCE | ASP 2
InPort_395368_1 | SINK | ASP 2
OutPort_395321_1 | SOURCE | ASP 2
InPort_796721_7 | SINK | ASP 2
OutPort_395368_0 | SOURCE | ASP 2
InPort_395506_1 | SINK | ASP 2
OutPort_395857_0 | SOURCE | ASP 2
InPort_796780_2 | SINK | ASP 2
OutPort_395684_0 | SOURCE | ASP 2
InPort_395684_1 | SINK | ASP 2
OutPort_796781_1 | SOURCE | ASP 2
InPort_395778_2 | SINK | ASP 2
OutPort_395763_0 | SOURCE | ASP 2
InPort_395763_1 | SINK | ASP 2
OutPort_395781_2 | SOURCE | ASP 2
InPort_395781_1 | SINK | ASP 2
OutPort_796721_0 | SOURCE | ASP 2
InPort_395857_1 | SINK | ASP 2
OutPort_395892_1 | SOURCE | ASP 2
InPort_808485_1 | SINK | ASP 1
OutPort_396562_0 | SOURCE | ASP 1
InPort_396562_1 | SINK | ASP 1
OutPort_798466_1 | SOURCE | ASP 1
InPort_762415_1 | SINK | ASP 1
OutPort_397059_0 | SOURCE | ASP 1
InPort_397059_1 | SINK | ASP 1
OutPort_397334_1 | SOURCE | ASP 1
InPort_397334_2 | SINK | ASP 1
OutPort_397074_0 | SOURCE | ASP 1
InPort_397456_2 | SINK | ASP 1
OutPort_397074_1 | SOURCE | ASP 1
InPort_397359_0 | SINK | ASP 1
OutPort_397074_2 | SOURCE | ASP 1
InPort_397074_3 | SINK | ASP 1
OutPort_759213_0 | SOURCE | ASP 1
InPort_397421_1 | SINK | ASP 1
OutPort_397443_1 | SOURCE | ASP 1
InPort_397443_0 | SINK | ASP 1
OutPort_397456_1 | SOURCE | ASP 1
InPort_397648_0 | SINK | ASP 1
OutPort_398314_2 | SOURCE | ASP 1
InPort_398315_3 | SINK | ASP 1
OutPort_397648_1 | SOURCE | ASP 1
InPort_398223_1 | SINK | ASP 1
OutPort_397731_0 | SOURCE | ASP 1
InPort_397731_1 | SINK | ASP 1
InPort_398122_0 | SINK | ASP 1
OutPort_397731_2 | SOURCE | ASP 1
InPort_398051_1 | SINK | ASP 1
OutPort_398122_1 | SOURCE | ASP 1
InPort_398200_0 | SINK | ASP 1
OutPort_398223_2 | SOURCE | ASP 1
InPort_398314_1 | SINK | ASP 1
OutPort_398200_1 | SOURCE | ASP 1
InPort_798386_0 | SINK | ASP 1
OutPort_398315_1 | SOURCE | ASP 1
InPort_398428_0 | SINK | ASP 1
OutPort_398446_2 | SOURCE | ASP 1
InPort_400099_0 | SINK | Mecánica Aire Aportació PK 1
OutPort_407901_1 | SOURCE | Mecánica Aire Aportació PK 1
InPort_404208_2 | SINK | Mecánica Aire Aportació PK 1
OutPort_400099_1 | SOURCE | Mecánica Aire Aportació PK 1
InPort_400186_0 | SINK | Mecánica Aire Aportació PK 1
OutPort_403837_1 | SOURCE | Mecánica Aire Aportació PK 1
InPort_400200_1 | SINK | Mecánica Aire Aportació PK 1
OutPort_400186_1 | SOURCE | Mecánica Aire Aportació PK 1
InPort_400599_0 | SINK | Mecánica Aire Aportació PK 1
OutPort_400200_2 | SOURCE | Mecánica Aire Aportació PK 1
InPort_437662_1 | SINK | Mecánica Aire Aportació PK 1
OutPort_400599_1 | SOURCE | Mecánica Aire Aportació PK 1
Port_401349_0 | SOURCEANDSINK | ASP 5
Port_401585_2 | SOURCEANDSINK | ASP 5
Port_401349_1 | SOURCEANDSINK | ASP 5
Port_402220_2 | SOURCEANDSINK | ASP 5
Port_401488_0 | SOURCEANDSINK | ASP 5
Port_402218_1 | SOURCEANDSINK | ASP 5
Port_401488_1 | SOURCEANDSINK | ASP 5
Port_405223_1 | SOURCEANDSINK | ASP 5
Port_401576_0 | SOURCEANDSINK | ASP 5
Port_401585_1 | SOURCEANDSINK | ASP 5
Port_401576_1 | SOURCEANDSINK | ASP 5
InPort_758757_0 | SINK | ASP 5
OutPort_401576_2 | SOURCE | ASP 5
InPort_401700_0 | SINK | ASP 5
OutPort_758757_1 | SOURCE | ASP 5
InPort_758655_1 | SINK | ASP 5
OutPort_401700_1 | SOURCE | ASP 5
Port_402051_0 | SOURCEANDSINK | ASP 5
Port_402385_1 | SOURCEANDSINK | ASP 5
Port_402051_1 | SOURCEANDSINK | ASP 5
Port_402220_1 | SOURCEANDSINK | ASP 5
Port_402218_2 | SOURCEANDSINK | ASP 5
Port_402386_0 | SOURCEANDSINK | ASP 5
InPort_402277_0 | SINK | ASP 5
OutPort_402385_3 | SOURCE | ASP 5
InPort_402562_1 | SINK | ASP 5
OutPort_402277_1 | SOURCE | ASP 5
Port_402385_2 | SOURCEANDSINK | ASP 5
Port_402386_1 | SOURCEANDSINK | ASP 5
InPort_402555_0 | SINK | ASP 5
OutPort_402562_2 | SOURCE | ASP 5
InPort_402741_2 | SINK | ASP 5
OutPort_402555_1 | SOURCE | ASP 5
InPort_402736_0 | SINK | ASP 5
OutPort_402741_1 | SOURCE | ASP 5
InPort_402957_1 | SINK | ASP 5
OutPort_402736_1 | SOURCE | ASP 5
InPort_758972_0 | SINK | ASP 5
OutPort_402736_2 | SOURCE | ASP 5
InPort_758786_1 | SINK | ASP 5
OutPort_402872_0 | SOURCE | ASP 5
InPort_402872_1 | SINK | ASP 5
OutPort_758972_1 | SOURCE | ASP 5
Port_403748_0 | SOURCEANDSINK | ASP 5
Port_408994_2 | SOURCEANDSINK | ASP 5
Port_403748_1 | SOURCEANDSINK | ASP 5
InPort_403837_2 | SINK | Mecánica Aire Aportació PK 1
OutPort_404071_0 | SOURCE | Mecánica Aire Aportació PK 1
InPort_404071_1 | SINK | Mecánica Aire Aportació PK 1
OutPort_404201_1 | SOURCE | Mecánica Aire Aportació PK 1
InPort_404186_0 | SINK | Mecánica Aire Aportació PK 1
OutPort_404208_1 | SOURCE | Mecánica Aire Aportació PK 1
InPort_404201_2 | SINK | Mecánica Aire Aportació PK 1
OutPort_404186_1 | SOURCE | Mecánica Aire Aportació PK 1
InPort_404269_0 | SINK | Mecánica Aire Aportació PK 1
OutPort_404842_2 | SOURCE | Mecánica Aire Aportació PK 1
InPort_404843_2 | SINK | Mecánica Aire Aportació PK 1
OutPort_404269_1 | SOURCE | Mecánica Aire Aportació PK 1
InPort_404465_1 | SINK | Mecánica Aire Aportació PK 1
OutPort_404783_0 | SOURCE | Mecánica Aire Aportació PK 1
InPort_404670_0 | SINK | Mecánica Aire Aportació PK 1
OutPort_404831_2 | SOURCE | Mecánica Aire Aportació PK 1
InPort_404842_1 | SINK | Mecánica Aire Aportació PK 1
OutPort_404670_1 | SOURCE | Mecánica Aire Aportació PK 1
InPort_404783_0 | SINK | Mecánica Aire Aportació PK 1
OutPort_404465_1 | SOURCE | Mecánica Aire Aportació PK 1
InPort_404831_1 | SINK | Mecánica Aire Aportació PK 1
OutPort_404783_1 | SOURCE | Mecánica Aire Aportació PK 1
InPort_407844_0 | SINK | Mecánica Aire Aportació PK 1
OutPort_404843_1 | SOURCE | Mecánica Aire Aportació PK 1
Port_405045_0 | SOURCEANDSINK | ASP 5
Port_405499_2 | SOURCEANDSINK | ASP 5
Port_405045_1 | SOURCEANDSINK | ASP 5
Port_405745_1 | SOURCEANDSINK | ASP 5
Port_405120_0 | SOURCEANDSINK | ASP 5
Port_408749_1 | SOURCEANDSINK | ASP 5
Port_405120_1 | SOURCEANDSINK | ASP 5
Port_408168_2 | SOURCEANDSINK | ASP 5
Port_405223_2 | SOURCEANDSINK | ASP 5
Port_405454_0 | SOURCEANDSINK | ASP 5
Port_405454_1 | SOURCEANDSINK | ASP 5
Port_405746_1 | SOURCEANDSINK | ASP 5
Port_405499_1 | SOURCEANDSINK | ASP 5
Port_408036_0 | SOURCEANDSINK | ASP 5
Port_405735_0 | SOURCEANDSINK | ASP 5
Port_405745_2 | SOURCEANDSINK | ASP 5
Port_405735_1 | SOURCEANDSINK | ASP 5
Port_405746_2 | SOURCEANDSINK | ASP 5
InPort_405942_1 | SINK | ASP 5
OutPort_406047_0 | SOURCE | ASP 5
InPort_406047_1 | SINK | ASP 5
OutPort_406200_1 | SOURCE | ASP 5
InPort_406119_1 | SINK | ASP 5
OutPort_406131_0 | SOURCE | ASP 5
InPort_406131_1 | SINK | ASP 5
OutPort_406267_1 | SOURCE | ASP 5
InPort_406200_0 | SINK | ASP 5
OutPort_408036_3 | SOURCE | ASP 5
InPort_406267_0 | SINK | ASP 5
OutPort_408036_2 | SOURCE | ASP 5
OutPort_407786_1 | SOURCE
InPort_407786_2 | SINK | ASP 6
OutPort_408482_0 | SOURCE | ASP 6
InPort_407901_2 | SINK | Mecánica Aire Aportació PK 1
OutPort_407844_1 | SOURCE | Mecánica Aire Aportació PK 1
Port_408036_1 | SOURCEANDSINK | ASP 5
Port_408169_2 | SOURCEANDSINK | ASP 5
Port_408158_0 | SOURCEANDSINK | ASP 5
Port_408168_1 | SOURCEANDSINK | ASP 5
Port_408158_1 | SOURCEANDSINK | ASP 5
Port_408169_1 | SOURCEANDSINK | ASP 5
InPort_408410_1 | SINK | ASP 6
OutPort_408462_0 | SOURCE | ASP 6
InPort_408462_1 | SINK | ASP 6
OutPort_408605_1 | SOURCE | ASP 6
InPort_408482_0 | SINK | ASP 6
OutPort_407786_2 | SOURCE | ASP 6
InPort_408605_2 | SINK | ASP 6
OutPort_408482_1 | SOURCE | ASP 6
Port_408719_0 | SOURCEANDSINK | ASP 5
Port_408749_2 | SOURCEANDSINK | ASP 5
Port_408719_1 | SOURCEANDSINK | ASP 5
Port_408775_1 | SOURCEANDSINK | ASP 5
Port_408757_0 | SOURCEANDSINK | ASP 5
Port_408993_1 | SOURCEANDSINK | ASP 5
Port_408757_1 | SOURCEANDSINK | ASP 5
Port_408775_2 | SOURCEANDSINK | ASP 5
Port_408993_2 | SOURCEANDSINK | ASP 5
Port_408994_1 | SOURCEANDSINK | ASP 5
InPort_424454_1 | SINK | AEPK 1
OutPort_424402_1 | SOURCE | AEPK 1
InPort_434898_1 | SINK | AEPK 1
OutPort_424454_0 | SOURCE | AEPK 1
InPort_424742_0 | SINK | AEPK 1
OutPort_424586_1 | SOURCE | AEPK 1
InPort_424726_0 | SINK | AEPK 1
OutPort_424676_1 | SOURCE | AEPK 1
InPort_436219_0 | SINK | AEPK 1
OutPort_424684_1 | SOURCE | AEPK 1
InPort_424790_1 | SINK | AEPK 1
OutPort_424726_1 | SOURCE | AEPK 1
InPort_424825_1 | SINK | AEPK 1
OutPort_424742_1 | SOURCE | AEPK 1
InPort_437736_5 | SINK | AEPK 1
OutPort_424790_0 | SOURCE | AEPK 1
InPort_437736_4 | SINK | AEPK 1
OutPort_424825_0 | SOURCE | AEPK 1
InPort_428752_0 | SINK | AEPK 2
OutPort_427907_1 | SOURCE | AEPK 2
InPort_427907_2 | SINK | AEPK 1
OutPort_428468_0 | SOURCE | AEPK 1
InPort_427907_3 | SINK
InPort_427907_4 | SINK
InPort_427907_5 | SINK
InPort_428468_1 | SINK | AEPK 1
OutPort_428606_2 | SOURCE | AEPK 1
InPort_428555_0 | SINK | AEPK 1
OutPort_428566_2 | SOURCE | AEPK 1
InPort_428604_1 | SINK | AEPK 1
OutPort_428555_1 | SOURCE | AEPK 1
InPort_428566_1 | SINK | AEPK 1
OutPort_437736_0 | SOURCE | AEPK 1
InPort_428570_0 | SINK | AEPK 1
OutPort_428604_2 | SOURCE | AEPK 1
InPort_428606_1 | SINK | AEPK 1
OutPort_428570_1 | SOURCE | AEPK 1
InPort_434250_1 | SINK | AEPK 2
OutPort_428752_1 | SOURCE | AEPK 2
InPort_431685_1 | SINK | Mecánica Aire Aportació PK EI 1
OutPort_432163_0 | SOURCE | Mecánica Aire Aportació PK EI 1
InPort_432551_0 | SINK | Mecánica Aire Aportació PK EI 2
OutPort_431685_2 | SOURCE | Mecánica Aire Aportació PK EI 2
OutPort_431685_3 | SOURCE
OutPort_431685_4 | SOURCE
OutPort_431685_5 | SOURCE
InPort_432059_0 | SINK | Mecánica Aire Aportació PK EI 1
OutPort_437681_1 | SOURCE | Mecánica Aire Aportació PK EI 1
InPort_435400_2 | SINK | Mecánica Aire Aportació PK EI 1
OutPort_432059_1 | SOURCE | Mecánica Aire Aportació PK EI 1
InPort_432163_1 | SINK | Mecánica Aire Aportació PK EI 1
OutPort_435400_1 | SOURCE | Mecánica Aire Aportació PK EI 1
InPort_432466_0 | SINK | Mecánica Aire Aportació PK EI 2
OutPort_432552_2 | SOURCE | Mecánica Aire Aportació PK EI 2
InPort_435015_2 | SINK | Mecánica Aire Aportació PK EI 2
OutPort_432466_1 | SOURCE | Mecánica Aire Aportació PK EI 2
InPort_432552_1 | SINK | Mecánica Aire Aportació PK EI 2
OutPort_432551_1 | SOURCE | Mecánica Aire Aportació PK EI 2
InPort_435014_1 | SINK | Mecánica Aire Aportació PK EI 2
OutPort_432683_0 | SOURCE | Mecánica Aire Aportació PK EI 2
InPort_432683_1 | SINK | Mecánica Aire Aportació PK EI 2
OutPort_435015_1 | SOURCE | Mecánica Aire Aportació PK EI 2
InPort_434033_1 | SINK | AEPK 2
OutPort_434250_2 | SOURCE | AEPK 2
Port_434033_2 | SOURCEANDSINK | AEPK 3
Port_434298_1 | SOURCEANDSINK | AEPK 3
Port_434270_0 | SOURCEANDSINK | AEPK 3
Port_434298_2 | SOURCEANDSINK | AEPK 3
Port_434270_1 | SOURCEANDSINK | AEPK 3
InPort_437736_3 | SINK | AEPK 1
OutPort_434898_0 | SOURCE | AEPK 1
InPort_436424_0 | SINK | Mecánica Aire Aportació PK EI 2
OutPort_435014_2 | SOURCE | Mecánica Aire Aportació PK EI 2
InPort_436277_1 | SINK | AEPK 1
OutPort_436219_1 | SOURCE | AEPK 1
InPort_437736_2 | SINK | AEPK 1
OutPort_436277_0 | SOURCE | AEPK 1
InPort_437681_2 | SINK | Mecánica Aire Aportació PK EI 1
OutPort_436349_0 | SOURCE | Mecánica Aire Aportació PK EI 1
InPort_436349_1 | SINK | Mecánica Aire Aportació PK EI 1
OutPort_437482_2 | SOURCE | Mecánica Aire Aportació PK EI 1
InPort_436521_1 | SINK | Mecánica Aire Aportació PK EI 2
OutPort_436424_1 | SOURCE | Mecánica Aire Aportació PK EI 2
InPort_519752_0 | SINK | Mecánica Aire Aportació PK EI 2
OutPort_436424_2 | SOURCE | Mecánica Aire Aportació PK EI 2
InPort_519779_0 | SINK | Mecánica Aire Aportació PK EI 2
OutPort_436424_3 | SOURCE | Mecánica Aire Aportació PK EI 2
InPort_519806_0 | SINK | Mecánica Aire Aportació PK EI 2
OutPort_436424_4 | SOURCE | Mecánica Aire Aportació PK EI 2
InPort_519833_0 | SINK | Mecánica Aire Aportació PK EI 2
OutPort_436424_5 | SOURCE | Mecánica Aire Aportació PK EI 2
InPort_436542_0 | SINK | Mecánica Aire Aportació PK 1
OutPort_437662_2 | SOURCE | Mecánica Aire Aportació PK 1
InPort_437482_1 | SINK | Mecánica Aire Aportació PK 1
OutPort_436542_1 | SOURCE | Mecánica Aire Aportació PK 1
InPort_437736_1 | SINK | AEPK 1
OutPort_438072_1 | SOURCE | AEPK 1
Port_438369_0 | SOURCEANDSINK | AI 24
Port_771538_1 | SOURCEANDSINK | AI 24
Port_438369_1 | SOURCEANDSINK | AI 24
Port_771398_2 | SOURCEANDSINK | AI 24
InPort_438774_0 | SINK | AI 24
OutPort_659542_2 | SOURCE | AI 24
InPort_517990_1 | SINK | AI 24
OutPort_438774_1 | SOURCE | AI 24
InPort_659541_0 | SINK | AI 24
OutPort_438774_3 | SOURCE | AI 24
Port_438783_1 | SOURCEANDSINK | AI 24
Port_438825_0 | SOURCEANDSINK | AI 24
Port_438783_2 | SOURCEANDSINK | AI 24
Port_771539_0 | SOURCEANDSINK | AI 24
InPort_438815_0 | SINK | AI 24
OutPort_439471_2 | SOURCE | AI 24
InPort_439456_2 | SINK | AI 24
OutPort_438815_1 | SOURCE | AI 24
InPort_438930_1 | SINK | AI 24
OutPort_438824_1 | SOURCE | AI 24
Port_438824_2 | SOURCEANDSINK | AI 24
Port_438825_1 | SOURCEANDSINK | AI 24
Port_438824_3 | SOURCEANDSINK | AI 24
Port_769148_0 | SOURCEANDSINK | AI 24
InPort_438969_0 | SINK | AI 24
OutPort_438930_2 | SOURCE | AI 24
InPort_438956_0 | SINK | AI 24
OutPort_659595_2 | SOURCE | AI 24
InPort_517772_1 | SINK | AI 24
OutPort_438956_1 | SOURCE | AI 24
InPort_659555_0 | SINK | AI 24
OutPort_438956_3 | SOURCE | AI 24
InPort_438968_1 | SINK | AI 24
OutPort_438969_1 | SOURCE | AI 24
InPort_659542_1 | SINK | AI 24
OutPort_438968_2 | SOURCE | AI 24
InPort_659595_1 | SINK | AI 24
OutPort_438968_3 | SOURCE | AI 24
InPort_439118_0 | SINK | AI 24
OutPort_516745_2 | SOURCE | AI 24
InPort_516781_1 | SINK | AI 24
OutPort_439118_1 | SOURCE | AI 24
InPort_516691_0 | SINK | AI 24
OutPort_439118_2 | SOURCE | AI 24
InPort_516721_0 | SINK | AI 24
OutPort_439118_3 | SOURCE | AI 24
InPort_516770_0 | SINK | AI 24
OutPort_439118_4 | SOURCE | AI 24
InPort_439130_1 | SINK | AI 24
OutPort_439131_0 | SOURCE | AI 24
InPort_439416_0 | SINK | AI 24
OutPort_439130_2 | SOURCE | AI 24
InPort_516745_1 | SINK | AI 24
OutPort_439130_3 | SOURCE | AI 24
InPort_439131_1 | SINK | AI 24
OutPort_769582_2 | SOURCE | AI 24
InPort_439188_0 | SINK | AI 24
OutPort_439767_1 | SOURCE | AI 24
InPort_517112_1 | SINK | AI 24
OutPort_439188_1 | SOURCE | AI 24
InPort_517294_0 | SINK | AI 24
OutPort_439188_2 | SOURCE | AI 24
InPort_439356_0 | SINK | AI 24
OutPort_516827_2 | SOURCE | AI 24
InPort_516843_1 | SINK | AI 24
OutPort_439356_1 | SOURCE | AI 24
InPort_516971_0 | SINK | AI 24
OutPort_439356_2 | SOURCE | AI 24
InPort_516999_0 | SINK | AI 24
OutPort_439356_3 | SOURCE | AI 24
InPort_517028_0 | SINK | AI 24
OutPort_439356_4 | SOURCE | AI 24
InPort_439415_1 | SINK | AI 24
OutPort_439416_1 | SOURCE | AI 24
InPort_439471_1 | SINK | AI 24
OutPort_439415_2 | SOURCE | AI 24
InPort_516827_1 | SINK | AI 24
OutPort_439415_3 | SOURCE | AI 24
InPort_439768_0 | SINK | AI 24
OutPort_439456_1 | SOURCE | AI 24
InPort_659816_1 | SINK | AI 24
OutPort_439757_0 | SOURCE | AI 24
InPort_439757_1 | SINK | AI 24
OutPort_660028_1 | SOURCE | AI 24
InPort_659910_0 | SINK | AI 24
OutPort_439757_2 | SOURCE | AI 24
InPort_439767_2 | SINK | AI 24
OutPort_439768_1 | SOURCE | AI 24
InPort_660023_0 | SINK | AI 24
OutPort_439767_3 | SOURCE | AI 24
InPort_517238_0 | SINK | AI 24
OutPort_439768_2 | SOURCE | AI 24
InPort_517266_0 | SINK | AI 24
OutPort_439768_3 | SOURCE | AI 24
Port_440051_0 | SOURCEANDSINK | AI 24
Port_771373_2 | SOURCEANDSINK | AI 24
Port_440051_1 | SOURCEANDSINK | AI 24
InPort_771544_2 | SINK | AI 24
OutPort_440205_0 | SOURCE | AI 24
InPort_440205_1 | SINK | AI 24
OutPort_771545_1 | SOURCE | AI 24
InPort_440228_0 | SINK | AI 24
OutPort_771544_1 | SOURCE | AI 24
InPort_517693_1 | SINK | AI 24
OutPort_440228_1 | SOURCE | AI 24
InPort_771489_0 | SINK | AI 24
OutPort_440228_3 | SOURCE | AI 24
InPort_441617_0 | SINK | AEWC 2
OutPort_441273_1 | SOURCE | AEWC 2
InPort_441417_0 | SINK | AEWC 2
OutPort_441693_1 | SOURCE | AEWC 2
InPort_804973_1 | SINK | AEWC 2
OutPort_441417_1 | SOURCE | AEWC 2
InPort_441693_2 | SINK | AEWC 2
OutPort_441617_1 | SOURCE | AEWC 2
InPort_441789_0 | SINK | AEWC 2
OutPort_805164_2 | SOURCE | AEWC 2
OutPort_441789_1 | SOURCE | AEWC 2
InPort_444196_1 | SINK | Mecánica Aire de retorno 55
OutPort_443499_0 | SOURCE | Mecánica Aire de retorno 55
InPort_443499_1 | SINK | Mecánica Aire de retorno 55
OutPort_518669_1 | SOURCE | Mecánica Aire de retorno 55
InPort_443499_2 | SINK | Mecánica Aire de retorno 55
OutPort_518842_0 | SOURCE | Mecánica Aire de retorno 55
InPort_444183_3 | SINK | Mecánica Aire de retorno 55
OutPort_443618_0 | SOURCE | Mecánica Aire de retorno 55
InPort_443618_1 | SINK | Mecánica Aire de retorno 55
OutPort_518653_1 | SOURCE | Mecánica Aire de retorno 55
InPort_443618_2 | SINK | Mecánica Aire de retorno 55
OutPort_518782_0 | SOURCE | Mecánica Aire de retorno 55
InPort_443706_0 | SINK | Mecánica Aire de retorno 55
OutPort_518699_2 | SOURCE | Mecánica Aire de retorno 55
InPort_659272_1 | SINK | Mecánica Aire de retorno 55
OutPort_443706_1 | SOURCE | Mecánica Aire de retorno 55
InPort_443770_3 | SINK | Mecánica Aire de retorno 55
OutPort_443753_0 | SOURCE | Mecánica Aire de retorno 55
InPort_443753_1 | SINK | Mecánica Aire de retorno 55
OutPort_518705_1 | SOURCE | Mecánica Aire de retorno 55
InPort_443753_2 | SINK | Mecánica Aire de retorno 55
OutPort_518515_0 | SOURCE | Mecánica Aire de retorno 55
InPort_518699_1 | SINK | Mecánica Aire de retorno 55
OutPort_443770_1 | SOURCE | Mecánica Aire de retorno 55
InPort_443770_2 | SINK | Mecánica Aire de retorno 55
OutPort_518700_1 | SOURCE | Mecánica Aire de retorno 55
InPort_443771_0 | SINK | Mecánica Aire de retorno 55
OutPort_443807_1 | SOURCE | Mecánica Aire de retorno 55
InPort_518700_2 | SINK | Mecánica Aire de retorno 55
OutPort_443771_1 | SOURCE | Mecánica Aire de retorno 55
InPort_443807_2 | SINK | Mecánica Aire de retorno 55
OutPort_443800_0 | SOURCE | Mecánica Aire de retorno 55
InPort_443800_1 | SINK | Mecánica Aire de retorno 55
OutPort_444296_2 | SOURCE | Mecánica Aire de retorno 55
InPort_443917_0 | SINK | Mecánica Aire de retorno 55
OutPort_659272_2 | SOURCE | Mecánica Aire de retorno 55
InPort_659323_1 | SINK | Mecánica Aire de retorno 55
OutPort_443917_1 | SOURCE | Mecánica Aire de retorno 55
InPort_444082_0 | SINK | Mecánica Aire de retorno 55
OutPort_444196_2 | SOURCE | Mecánica Aire de retorno 55
InPort_444183_2 | SINK | Mecánica Aire de retorno 55
OutPort_444082_1 | SOURCE | Mecánica Aire de retorno 55
InPort_444228_1 | SINK | Mecánica Aire de retorno 55
OutPort_444183_1 | SOURCE | Mecánica Aire de retorno 55
InPort_444296_1 | SINK | Mecánica Aire de retorno 55
OutPort_444228_0 | SOURCE | Mecánica Aire de retorno 55
InPort_444376_0 | SINK | AEWC 1
OutPort_444373_1 | SOURCE | AEWC 1
InPort_444374_0 | SINK | AEWC 1
OutPort_444378_1 | SOURCE | AEWC 1
InPort_444382_1 | SINK | AEWC 1
OutPort_444374_1 | SOURCE | AEWC 1
InPort_444378_2 | SINK | AEWC 1
OutPort_444376_1 | SOURCE | AEWC 1
InPort_444380_0 | SINK | AEWC 1
OutPort_444382_2 | SOURCE | AEWC 1
OutPort_444380_1 | SOURCE | AEWC 1
InPort_767561_2 | SINK | AE 1
OutPort_450455_1 | SOURCE | AE 1
InPort_450455_2 | SINK | AI 25
OutPort_767316_1 | SOURCE | AI 25
InPort_763977_0 | SINK | AE 2
OutPort_450455_3 | SOURCE | AE 2
InPort_450455_4 | SINK | AP 1
OutPort_764507_1 | SOURCE | AP 1
InPort_510292_1 | SINK | AI 22
OutPort_450942_0 | SOURCE | AI 22
InPort_450942_1 | SINK | AI 22
OutPort_454578_1 | SOURCE | AI 22
InPort_454525_0 | SINK | AI 22
OutPort_451289_1 | SOURCE | AI 22
InPort_451289_2 | SINK | AI 22
OutPort_451290_0 | SOURCE | AI 22
InPort_453630_0 | SINK | AI 22
OutPort_451289_3 | SOURCE | AI 22
InPort_451290_1 | SINK | AI 22
InPort_451456_0 | SINK | AI 22
OutPort_681043_2 | SOURCE | AI 22
InPort_452911_3 | SINK | AI 22
