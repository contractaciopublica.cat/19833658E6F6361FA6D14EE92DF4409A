Properties of the parts of a building model (IFC2X3), part 5 of 9

# IfcDistributionPort (4648)
Name | FlowDirection | Group
Port_771539_1 | SOURCEANDSINK | AI 24
InPort_771545_2 | SINK | AI 24
OutPort_771538_3 | SOURCE | AI 24
Port_775476_0 | SOURCEANDSINK | ACIS 1
Port_775476_1 | SOURCEANDSINK | ACIS 1
Port_775873_1 | SOURCEANDSINK | ACIS 1
Port_775543_0 | SOURCEANDSINK | ACIP 2
Port_775543_1 | SOURCEANDSINK | ACIP 2
Port_775968_1 | SOURCEANDSINK | ACIP 2
Port_775554_0 | SOURCEANDSINK | AFIS 1
Port_777439_2 | SOURCEANDSINK | AFIS 1
Port_775554_1 | SOURCEANDSINK | AFIS 1
Port_777441_2 | SOURCEANDSINK | AFIS 1
InPort_775565_0 | SINK | AFIP 1
OutPort_777433_2 | SOURCE | AFIP 1
InPort_777435_2 | SINK | AFIP 1
OutPort_775565_1 | SOURCE | AFIP 1
Port_775862_0 | SOURCEANDSINK | ACIS 1
Port_775873_2 | SOURCEANDSINK | ACIS 1
Port_775862_1 | SOURCEANDSINK | ACIS 1
Port_777488_1 | SOURCEANDSINK | ACIS 1
Port_775960_0 | SOURCEANDSINK | ACIP 2
Port_775968_2 | SOURCEANDSINK | ACIP 2
Port_775960_1 | SOURCEANDSINK | ACIP 2
Port_778523_1 | SOURCEANDSINK | ACIP 2
Port_776170_0 | SOURCEANDSINK | AFIS 1
Port_777441_1 | SOURCEANDSINK | AFIS 1
Port_776170_1 | SOURCEANDSINK | AFIS 1
Port_777552_1 | SOURCEANDSINK | AFIS 1
InPort_776231_0 | SINK | AFIS 2
OutPort_777435_1 | SOURCE | AFIS 2
InPort_776231_1 | SINK | AFIS 2
OutPort_777627_1 | SOURCE | AFIS 2
InPort_776290_0 | SINK | ACIS 2
InPort_776764_2 | SINK | ACIS 2
OutPort_776290_1 | SOURCE | ACIS 2
Port_776292_0 | SOURCEANDSINK | ACIP 1
Port_776766_2 | SOURCEANDSINK | ACIP 1
Port_776292_1 | SOURCEANDSINK | ACIP 1
InPort_776294_0 | SINK | AFIS 3
InPort_776768_2 | SINK | AFIS 3
OutPort_776294_1 | SOURCE | AFIS 3
Port_776296_0 | SOURCEANDSINK | AFIP 2
Port_776296_1 | SOURCEANDSINK | AFIP 2
Port_777780_2 | SOURCEANDSINK | AFIP 2
InPort_776533_0 | SINK | ACIS 2
OutPort_776764_1 | SOURCE | ACIS 2
InPort_776793_1 | SINK | ACIS 2
OutPort_776533_1 | SOURCE | ACIS 2
Port_776604_0 | SOURCEANDSINK | ACIP 1
Port_776766_1 | SOURCEANDSINK | ACIP 1
Port_776604_1 | SOURCEANDSINK | ACIP 1
Port_776901_1 | SOURCEANDSINK | ACIP 1
InPort_776662_0 | SINK | AFIS 3
OutPort_776768_1 | SOURCE | AFIS 3
InPort_778292_2 | SINK | AFIS 3
OutPort_776662_1 | SOURCE | AFIS 3
Port_776724_0 | SOURCEANDSINK | AFIP 2
Port_777778_2 | SOURCEANDSINK | AFIP 2
Port_776724_1 | SOURCEANDSINK | AFIP 2
Port_777780_1 | SOURCEANDSINK | AFIP 2
InPort_776785_0 | SINK | AFIP 3
OutPort_776793_2 | SOURCE | AFIP 3
InPort_777912_1 | SINK | AFIP 3
OutPort_776785_1 | SOURCE | AFIP 3
Port_776893_0 | SOURCEANDSINK | ACIP 1
Port_776901_2 | SOURCEANDSINK | ACIP 1
Port_776893_1 | SOURCEANDSINK | ACIP 1
Port_777957_1 | SOURCEANDSINK | ACIP 1
InPort_777431_2 | SINK | AFIP 1
OutPort_777083_0 | SOURCE | AFIP 1
InPort_777083_1 | SINK | AFIP 1
Port_777177_0 | SOURCEANDSINK | AFIS 1
Port_777429_2 | SOURCEANDSINK | AFIS 1
Port_777177_1 | SOURCEANDSINK | AFIS 1
InPort_777243_0 | SINK | AFIP 1
OutPort_777431_1 | SOURCE | AFIP 1
InPort_777433_1 | SINK | AFIP 1
OutPort_777243_1 | SOURCE | AFIP 1
Port_777245_0 | SOURCEANDSINK | AFIS 1
Port_777429_1 | SOURCEANDSINK | AFIS 1
Port_777245_1 | SOURCEANDSINK | AFIS 1
Port_777439_1 | SOURCEANDSINK | AFIS 1
Port_777482_0 | SOURCEANDSINK | ACIS 1
Port_777488_2 | SOURCEANDSINK | ACIS 1
Port_777482_1 | SOURCEANDSINK | ACIS 1
Port_777521_0 | SOURCEANDSINK | ACIP 2
Port_778523_2 | SOURCEANDSINK | ACIP 2
Port_777521_1 | SOURCEANDSINK | ACIP 2
Port_777546_0 | SOURCEANDSINK | AFIS 1
Port_777552_2 | SOURCEANDSINK | AFIS 1
Port_777546_1 | SOURCEANDSINK | AFIS 1
InPort_777627_2 | SINK | AFIS 2
OutPort_777621_0 | SOURCE | AFIS 2
InPort_777621_1 | SINK | AFIS 2
Port_777656_0 | SOURCEANDSINK | AFIP 2
Port_777778_1 | SOURCEANDSINK | AFIP 2
Port_777656_1 | SOURCEANDSINK | AFIP 2
Port_778229_2 | SOURCEANDSINK | AFIP 2
InPort_777912_2 | SINK | AFIP 3
OutPort_777904_0 | SOURCE | AFIP 3
InPort_777904_1 | SINK | ACIP 3
Port_777951_0 | SOURCEANDSINK | ACIP 1
Port_777957_2 | SOURCEANDSINK | ACIP 1
Port_777951_1 | SOURCEANDSINK | ACIP 1
InPort_777990_0 | SINK | AFIP 4
OutPort_778294_1 | SOURCE | AFIP 4
InPort_777990_1 | SINK | AFIP 4
OutPort_778335_1 | SOURCE | AFIP 4
Port_778031_0 | SOURCEANDSINK | AFIP 2
Port_778231_1 | SOURCEANDSINK | AFIP 2
Port_778031_1 | SOURCEANDSINK | AFIP 2
Port_778369_1 | SOURCEANDSINK | AFIP 2
Port_778162_0 | SOURCEANDSINK | AFIP 2
Port_778229_1 | SOURCEANDSINK | AFIP 2
Port_778162_1 | SOURCEANDSINK | AFIP 2
Port_778231_2 | SOURCEANDSINK | AFIP 2
InPort_778194_0 | SINK | AFIS 3
OutPort_778292_1 | SOURCE | AFIS 3
InPort_778294_2 | SINK | AFIS 3
OutPort_778194_1 | SOURCE | AFIS 3
InPort_778335_2 | SINK | AFIP 4
OutPort_778329_0 | SOURCE | AFIP 4
InPort_778329_1 | SINK | AFIP 4
Port_778363_0 | SOURCEANDSINK | AFIP 2
Port_778369_2 | SOURCEANDSINK | AFIP 2
Port_778363_1 | SOURCEANDSINK | AFIP 2
Port_778604_0 | SOURCEANDSINK | ACIS 3
Port_778604_1 | SOURCEANDSINK | ACIS 3
Port_779165_1 | SOURCEANDSINK | ACIS 3
Port_778606_0 | SOURCEANDSINK | ACIP 4
Port_778606_1 | SOURCEANDSINK | ACIP 4
Port_779067_1 | SOURCEANDSINK | ACIP 4
Port_778734_0 | SOURCEANDSINK | AFIP 6
Port_779581_1 | SOURCEANDSINK | AFIP 6
Port_778734_1 | SOURCEANDSINK | AFIP 6
Port_778792_0 | SOURCEANDSINK | AFIS 5
Port_779583_1 | SOURCEANDSINK | AFIS 5
Port_778792_1 | SOURCEANDSINK | AFIS 5
Port_779007_0 | SOURCEANDSINK | ACIS 3
Port_779161_1 | SOURCEANDSINK | ACIS 3
Port_779007_1 | SOURCEANDSINK | ACIS 3
Port_779887_1 | SOURCEANDSINK | ACIS 3
Port_779059_0 | SOURCEANDSINK | ACIP 4
Port_779067_2 | SOURCEANDSINK | ACIP 4
Port_779059_1 | SOURCEANDSINK | ACIP 4
Port_779846_1 | SOURCEANDSINK | ACIP 4
Port_779151_0 | SOURCEANDSINK | ACIS 3
Port_779161_2 | SOURCEANDSINK | ACIS 3
Port_779151_1 | SOURCEANDSINK | ACIS 3
Port_779165_2 | SOURCEANDSINK | ACIS 3
Port_779535_0 | SOURCEANDSINK | AFIP 6
Port_779608_1 | SOURCEANDSINK | AFIP 6
Port_779535_1 | SOURCEANDSINK | AFIP 6
Port_779581_2 | SOURCEANDSINK | AFIP 6
Port_779537_0 | SOURCEANDSINK | AFIS 5
Port_779583_2 | SOURCEANDSINK | AFIS 5
Port_779537_1 | SOURCEANDSINK | AFIS 5
Port_779665_1 | SOURCEANDSINK | AFIS 5
Port_779600_0 | SOURCEANDSINK | AFIP 6
Port_779608_2 | SOURCEANDSINK | AFIP 6
Port_779600_1 | SOURCEANDSINK | AFIP 6
Port_779694_1 | SOURCEANDSINK | AFIP 6
Port_779657_0 | SOURCEANDSINK | AFIS 5
Port_779665_2 | SOURCEANDSINK | AFIS 5
Port_779657_1 | SOURCEANDSINK | AFIS 5
Port_779811_1 | SOURCEANDSINK | AFIS 5
Port_779686_0 | SOURCEANDSINK | AFIP 6
Port_779694_2 | SOURCEANDSINK | AFIP 6
Port_779686_1 | SOURCEANDSINK | AFIP 6
Port_779803_0 | SOURCEANDSINK | AFIS 5
Port_779811_2 | SOURCEANDSINK | AFIS 5
Port_779803_1 | SOURCEANDSINK | AFIS 5
Port_779838_0 | SOURCEANDSINK | ACIP 4
Port_779846_2 | SOURCEANDSINK | ACIP 4
Port_779838_1 | SOURCEANDSINK | ACIP 4
Port_779879_0 | SOURCEANDSINK | ACIS 3
Port_779887_2 | SOURCEANDSINK | ACIS 3
Port_779879_1 | SOURCEANDSINK | ACIS 3
InPort_779909_0 | SINK | ACIS 4
InPort_780261_2 | SINK | ACIS 4
OutPort_779909_1 | SOURCE | ACIS 4
Port_779911_0 | SOURCEANDSINK | ACIP 5
Port_780270_2 | SOURCEANDSINK | ACIP 5
Port_779911_1 | SOURCEANDSINK | ACIP 5
InPort_780276_2 | SINK | AFIS 4
OutPort_779913_0 | SOURCE | AFIS 4
InPort_779913_1 | SINK | AFIS 4
Port_779915_0 | SOURCEANDSINK | AFIP 5
Port_779915_1 | SOURCEANDSINK | AFIP 5
Port_780278_2 | SOURCEANDSINK | AFIP 5
InPort_779917_0 | SINK | ACIS 4
OutPort_780261_1 | SOURCE | ACIS 4
InPort_780263_2 | SINK | ACIS 4
OutPort_779917_1 | SOURCE | ACIS 4
Port_779919_0 | SOURCEANDSINK | ACIP 5
Port_780270_1 | SOURCEANDSINK | ACIP 5
Port_779919_1 | SOURCEANDSINK | ACIP 5
Port_780272_2 | SOURCEANDSINK | ACIP 5
InPort_779921_0 | SINK | AFIS 4
OutPort_780276_1 | SOURCE | AFIS 4
InPort_779949_2 | SINK | AFIS 4
OutPort_779921_1 | SOURCE | AFIS 4
Port_779923_0 | SOURCEANDSINK | AFIP 5
Port_780278_1 | SOURCEANDSINK | AFIP 5
Port_779923_1 | SOURCEANDSINK | AFIP 5
Port_780280_2 | SOURCEANDSINK | AFIP 5
InPort_780263_1 | SINK | ACIS 4
OutPort_779925_0 | SOURCE | ACIS 4
InPort_779925_1 | SINK | AFIP 8
Port_779929_0 | SOURCEANDSINK | ACIP 5
Port_780272_1 | SOURCEANDSINK | ACIP 5
Port_779929_1 | SOURCEANDSINK | ACIP 5
Port_779933_0 | SOURCEANDSINK | AFIP 5
Port_780280_1 | SOURCEANDSINK | AFIP 5
Port_779933_1 | SOURCEANDSINK | AFIP 5
Port_779945_2 | SOURCEANDSINK | AFIP 5
InPort_779951_1 | SINK | AFIS 4
OutPort_779937_0 | SOURCE | AFIS 4
InPort_779937_1 | SINK | AFIP 9
Port_779939_0 | SOURCEANDSINK | AFIP 5
Port_779947_1 | SOURCEANDSINK | AFIP 5
Port_779939_1 | SOURCEANDSINK | AFIP 5
Port_779941_0 | SOURCEANDSINK | AFIP 5
Port_779945_1 | SOURCEANDSINK | AFIP 5
Port_779941_1 | SOURCEANDSINK | AFIP 5
Port_779947_2 | SOURCEANDSINK | AFIP 5
InPort_779943_0 | SINK | AFIS 4
OutPort_779949_1 | SOURCE | AFIS 4
InPort_779951_2 | SINK | AFIS 4
OutPort_779943_1 | SOURCE | AFIS 4
Port_780289_0 | SOURCEANDSINK | ACIS 5
Port_780289_1 | SOURCEANDSINK | ACIS 5
Port_782196_1 | SOURCEANDSINK | ACIS 5
Port_780291_0 | SOURCEANDSINK | ACIP 6
Port_781811_1 | SOURCEANDSINK | ACIP 6
Port_780291_1 | SOURCEANDSINK | ACIP 6
Port_780293_0 | SOURCEANDSINK | AFIP 7
Port_781807_1 | SOURCEANDSINK | AFIP 7
Port_780293_1 | SOURCEANDSINK | AFIP 7
InPort_782202_1 | SINK | AFIS 6
OutPort_780295_0 | SOURCE | AFIS 6
InPort_780295_1 | SINK | AFIS 6
InPort_780735_1 | SINK | Mecánica Aire de retorno 8
OutPort_780555_1 | SOURCE | Mecánica Aire de retorno 8
InPort_780642_2 | SINK | Mecánica Aire de retorno 8
OutPort_780627_0 | SOURCE | Mecánica Aire de retorno 8
InPort_780627_1 | SINK | Mecánica Aire de retorno 8
OutPort_780655_1 | SOURCE | Mecánica Aire de retorno 8
InPort_780655_2 | SINK | Mecánica Aire de retorno 8
OutPort_780718_0 | SOURCE | Mecánica Aire de retorno 8
InPort_780718_1 | SINK | Mecánica Aire de retorno 8
OutPort_780738_1 | SOURCE | Mecánica Aire de retorno 8
InPort_780723_0 | SINK | Mecánica Aire de retorno 8
OutPort_780735_2 | SOURCE | Mecánica Aire de retorno 8
InPort_780738_2 | SINK | Mecánica Aire de retorno 8
OutPort_780723_1 | SOURCE | Mecánica Aire de retorno 8
Port_781488_0 | SOURCEANDSINK | ACIS 5
Port_782347_1 | SOURCEANDSINK | ACIS 5
Port_781488_1 | SOURCEANDSINK | ACIS 5
Port_782196_2 | SOURCEANDSINK | ACIS 5
Port_781490_0 | SOURCEANDSINK | ACIP 6
Port_782308_1 | SOURCEANDSINK | ACIP 6
Port_781490_1 | SOURCEANDSINK | ACIP 6
Port_782198_2 | SOURCEANDSINK | ACIP 6
InPort_782272_1 | SINK | AFIS 6
OutPort_781691_0 | SOURCE | AFIS 6
InPort_781691_1 | SINK | AFIS 6
OutPort_782202_2 | SOURCE | AFIS 6
Port_781777_0 | SOURCEANDSINK | AFIP 7
Port_782237_1 | SOURCEANDSINK | AFIP 7
Port_781777_1 | SOURCEANDSINK | AFIP 7
Port_782204_2 | SOURCEANDSINK | AFIP 7
Port_781807_2 | SOURCEANDSINK | AFIP 7
Port_782238_0 | SOURCEANDSINK | AFIP 7
Port_781811_2 | SOURCEANDSINK | ACIP 6
Port_782309_0 | SOURCEANDSINK | ACIP 6
Port_781897_0 | SOURCEANDSINK | ACIS 5
Port_782194_1 | SOURCEANDSINK | ACIS 5
Port_781897_1 | SOURCEANDSINK | ACIS 5
Port_784914_2 | SOURCEANDSINK | ACIS 5
Port_781899_0 | SOURCEANDSINK | ACIP 6
Port_782198_1 | SOURCEANDSINK | ACIP 6
Port_781899_1 | SOURCEANDSINK | ACIP 6
Port_782502_2 | SOURCEANDSINK | ACIP 6
InPort_781901_0 | SINK | AFIS 6
OutPort_782200_1 | SOURCE | AFIS 6
InPort_782504_2 | SINK | AFIS 6
OutPort_781901_1 | SOURCE | AFIS 6
Port_781903_0 | SOURCEANDSINK | AFIP 7
Port_782204_1 | SOURCEANDSINK | AFIP 7
Port_781903_1 | SOURCEANDSINK | AFIP 7
Port_782506_2 | SOURCEANDSINK | AFIP 7
Port_782172_0 | SOURCEANDSINK | ACIS 5
Port_783179_1 | SOURCEANDSINK | ACIS 5
Port_782172_1 | SOURCEANDSINK | ACIS 5
Port_783011_1 | SOURCEANDSINK | ACIS 5
Port_782174_0 | SOURCEANDSINK | ACIP 6
Port_784297_1 | SOURCEANDSINK | ACIP 6
Port_782174_1 | SOURCEANDSINK | ACIP 6
Port_784261_2 | SOURCEANDSINK | ACIP 6
InPort_783097_1 | SINK | AFIS 6
OutPort_782176_0 | SOURCE | AFIS 6
InPort_782176_1 | SINK | AFIS 6
OutPort_783021_2 | SOURCE | AFIS 6
Port_782178_0 | SOURCEANDSINK | AFIP 7
Port_783055_1 | SOURCEANDSINK | AFIP 7
Port_782178_1 | SOURCEANDSINK | AFIP 7
Port_783025_1 | SOURCEANDSINK | AFIP 7
Port_782194_2 | SOURCEANDSINK | ACIS 5
Port_782348_0 | SOURCEANDSINK | ACIS 5
InPort_782200_2 | SINK | AFIS 6
OutPort_782273_0 | SOURCE | AFIS 6
Port_782235_0 | SOURCEANDSINK | AFIP 7
Port_782237_3 | SOURCEANDSINK | AFIP 7
Port_782235_1 | SOURCEANDSINK | AFIP 7
Port_782242_1 | SOURCEANDSINK | AFIP 7
Port_782237_2 | SOURCEANDSINK | AFIP 7
Port_782238_1 | SOURCEANDSINK | AFIP 7
Port_782242_2 | SOURCEANDSINK | AFIP 7
Port_783056_0 | SOURCEANDSINK | AFIP 7
InPort_782270_0 | SINK | AFIS 6
OutPort_782272_3 | SOURCE | AFIS 6
InPort_783021_1 | SINK | AFIS 6
OutPort_782270_1 | SOURCE | AFIS 6
InPort_782273_1 | SINK | AFIS 6
OutPort_782272_2 | SOURCE | AFIS 6
Port_782306_0 | SOURCEANDSINK | ACIP 6
Port_782308_3 | SOURCEANDSINK | ACIP 6
Port_782306_1 | SOURCEANDSINK | ACIP 6
Port_784261_1 | SOURCEANDSINK | ACIP 6
Port_782308_2 | SOURCEANDSINK | ACIP 6
Port_782309_1 | SOURCEANDSINK | ACIP 6
Port_782345_0 | SOURCEANDSINK | ACIS 5
Port_782347_3 | SOURCEANDSINK | ACIS 5
Port_782345_1 | SOURCEANDSINK | ACIS 5
Port_782351_1 | SOURCEANDSINK | ACIS 5
Port_782347_2 | SOURCEANDSINK | ACIS 5
Port_782348_1 | SOURCEANDSINK | ACIS 5
Port_782351_2 | SOURCEANDSINK | ACIS 5
Port_783180_0 | SOURCEANDSINK | ACIS 5
InPort_785150_1 | SINK | AI 21
OutPort_782378_1 | SOURCE | AI 21
Port_782447_0 | SOURCEANDSINK | ACIS 5
Port_784905_2 | SOURCEANDSINK | ACIS 5
Port_782447_1 | SOURCEANDSINK | ACIS 5
Port_784912_2 | SOURCEANDSINK | ACIS 5
Port_782449_0 | SOURCEANDSINK | ACIP 6
Port_784886_2 | SOURCEANDSINK | ACIP 6
Port_782449_1 | SOURCEANDSINK | ACIP 6
Port_784442_1 | SOURCEANDSINK | ACIP 6
InPort_782451_0 | SINK | AFIS 6
OutPort_782504_1 | SOURCE | AFIS 6
InPort_784605_1 | SINK | AFIS 6
OutPort_782451_1 | SOURCE | AFIS 6
Port_782453_0 | SOURCEANDSINK | AFIP 7
Port_782506_1 | SOURCEANDSINK | AFIP 7
Port_782453_1 | SOURCEANDSINK | AFIP 7
Port_784632_1 | SOURCEANDSINK | AFIP 7
Port_782502_1 | SOURCEANDSINK | ACIP 6
Port_784735_0 | SOURCEANDSINK | ACIP 6
InPort_782531_0 | SINK | AFIS 6
OutPort_783019_2 | SOURCE | AFIS 6
InPort_783348_1 | SINK | AFIS 6
OutPort_782531_1 | SOURCE | AFIS 6
Port_782533_0 | SOURCEANDSINK | AFIP 7
Port_783025_2 | SOURCEANDSINK | AFIP 7
Port_782533_1 | SOURCEANDSINK | AFIP 7
Port_783374_1 | SOURCEANDSINK | AFIP 7
Port_782572_0 | SOURCEANDSINK | ACIS 5
Port_783011_2 | SOURCEANDSINK | ACIS 5
Port_782572_1 | SOURCEANDSINK | ACIS 5
Port_783225_2 | SOURCEANDSINK | ACIS 5
Port_782574_0 | SOURCEANDSINK | ACIP 6
Port_783013_2 | SOURCEANDSINK | ACIP 6
Port_782574_1 | SOURCEANDSINK | ACIP 6
Port_783250_2 | SOURCEANDSINK | ACIP 6
InPort_784265_2 | SINK | ACIS 5
OutPort_782589_0 | SOURCE | ACIS 5
InPort_782589_1 | SINK | ACIS 5
OutPort_784269_2 | SOURCE | ACIS 5
InPort_783059_2 | SINK | AFIS 8
OutPort_782984_0 | SOURCE | AFIS 8
InPort_782984_1 | SINK | AFIS 8
OutPort_783740_1 | SOURCE | AFIS 8
InPort_783101_2 | SINK | AFIP 11
OutPort_782986_0 | SOURCE | AFIP 11
InPort_782986_1 | SINK | AFIP 11
OutPort_783698_1 | SOURCE | AFIP 11
Port_783013_1 | SOURCEANDSINK | ACIP 6
Port_784298_0 | SOURCEANDSINK | ACIP 6
InPort_783019_1 | SINK | AFIS 6
OutPort_783098_0 | SOURCE | AFIS 6
InPort_783055_3 | SINK | AFIP 7
OutPort_783053_0 | SOURCE | AFIP 7
InPort_783053_1 | SINK | AFIS 8
OutPort_783059_1 | SOURCE | AFIS 8
Port_783055_2 | SOURCEANDSINK | AFIP 7
Port_783056_1 | SOURCEANDSINK | AFIP 7
InPort_783097_3 | SINK | AFIS 6
OutPort_783095_0 | SOURCE | AFIS 6
InPort_783095_1 | SINK | AFIP 11
OutPort_783101_1 | SOURCE | AFIP 11
InPort_783098_1 | SINK | AFIS 6
OutPort_783097_2 | SOURCE | AFIS 6
InPort_783177_0 | SINK | ACIS 5
OutPort_783179_3 | SOURCE | ACIS 5
InPort_784269_1 | SINK | ACIS 5
OutPort_783177_1 | SOURCE | ACIS 5
Port_783179_2 | SOURCEANDSINK | ACIS 5
Port_783180_1 | SOURCEANDSINK | ACIS 5
Port_783217_0 | SOURCEANDSINK | ACIS 5
Port_783225_1 | SOURCEANDSINK | ACIS 5
Port_783217_1 | SOURCEANDSINK | ACIS 5
Port_783599_1 | SOURCEANDSINK | ACIS 5
Port_783242_0 | SOURCEANDSINK | ACIP 6
Port_783250_1 | SOURCEANDSINK | ACIP 6
Port_783242_1 | SOURCEANDSINK | ACIP 6
Port_783633_1 | SOURCEANDSINK | ACIP 6
InPort_783340_0 | SINK | AFIS 6
OutPort_783348_2 | SOURCE | AFIS 6
InPort_783416_1 | SINK | AFIS 6
OutPort_783340_1 | SOURCE | AFIS 6
Port_783366_0 | SOURCEANDSINK | AFIP 7
Port_783374_2 | SOURCEANDSINK | AFIP 7
Port_783366_1 | SOURCEANDSINK | AFIP 7
Port_783473_1 | SOURCEANDSINK | AFIP 7
InPort_783416_2 | SINK | AFIS 6
OutPort_783408_0 | SOURCE | AFIS 6
InPort_783408_1 | SINK | AFIP 10
OutPort_783534_1 | SOURCE | AFIP 10
Port_783434_0 | SOURCEANDSINK | AFIP 7
Port_783473_2 | SOURCEANDSINK | AFIP 7
Port_783434_1 | SOURCEANDSINK | AFIP 7
Port_783509_1 | SOURCEANDSINK | AFIP 7
Port_783501_0 | SOURCEANDSINK | AFIP 7
Port_783509_2 | SOURCEANDSINK | AFIP 7
Port_783501_1 | SOURCEANDSINK | AFIP 7
InPort_783534_2 | SINK | AFIP 10
OutPort_783526_0 | SOURCE | AFIP 10
InPort_783526_1 | SINK | AFIP 10
Port_783591_0 | SOURCEANDSINK | ACIS 5
Port_783599_2 | SOURCEANDSINK | ACIS 5
Port_783591_1 | SOURCEANDSINK | ACIS 5
Port_783607_1 | SOURCEANDSINK | ACIS 5
Port_783601_0 | SOURCEANDSINK | ACIS 5
Port_783607_2 | SOURCEANDSINK | ACIS 5
Port_783601_1 | SOURCEANDSINK | ACIS 5
Port_783625_0 | SOURCEANDSINK | ACIP 6
Port_783633_2 | SOURCEANDSINK | ACIP 6
Port_783625_1 | SOURCEANDSINK | ACIP 6
Port_783643_1 | SOURCEANDSINK | ACIP 6
Port_783635_0 | SOURCEANDSINK | ACIP 6
Port_783643_2 | SOURCEANDSINK | ACIP 6
Port_783635_1 | SOURCEANDSINK | ACIP 6
InPort_783698_2 | SINK | AFIP 11
OutPort_783690_0 | SOURCE | AFIP 11
InPort_783690_1 | SINK | AFIP 11
OutPort_783796_1 | SOURCE | AFIP 11
InPort_783740_2 | SINK | AFIS 8
OutPort_783713_0 | SOURCE | AFIS 8
InPort_783713_1 | SINK | AFIS 8
OutPort_783762_1 | SOURCE | AFIS 8
InPort_783762_2 | SINK | AFIS 8
OutPort_783754_0 | SOURCE | AFIS 8
InPort_783754_1 | SINK | AFIS 8
OutPort_783770_1 | SOURCE | AFIS 8
InPort_783770_2 | SINK | AFIS 8
OutPort_783764_0 | SOURCE | AFIS 8
InPort_783764_1 | SINK | AFIS 8
InPort_783796_2 | SINK | AFIP 11
OutPort_783788_0 | SOURCE | AFIP 11
InPort_783788_1 | SINK | AFIP 11
OutPort_783864_1 | SOURCE | AFIP 11
InPort_783864_2 | SINK | AFIP 11
OutPort_783856_0 | SOURCE | AFIP 11
InPort_783856_1 | SINK | AFIP 11
InPort_784039_0 | SINK | ACIS 8
OutPort_784305_2 | SOURCE | ACIS 8
InPort_784307_2 | SINK | ACIS 8
OutPort_784039_1 | SOURCE | ACIS 8
InPort_784305_1 | SINK | ACIS 8
OutPort_784052_0 | SOURCE | ACIS 8
InPort_784052_1 | SINK | ACIS 8
OutPort_784121_1 | SOURCE | ACIS 8
InPort_784121_2 | SINK | ACIS 8
OutPort_784113_0 | SOURCE | ACIS 8
InPort_784113_1 | SINK | ACIS 8
OutPort_784382_1 | SOURCE | ACIS 8
InPort_784265_1 | SINK | ACIS 5
OutPort_784136_0 | SOURCE | ACIS 5
InPort_784136_1 | SINK | ACIP 7
OutPort_784338_1 | SOURCE | ACIP 7
InPort_784297_3 | SINK | ACIP 6
OutPort_784295_0 | SOURCE | ACIP 6
InPort_784295_1 | SINK | ACIS 8
OutPort_784307_1 | SOURCE | ACIS 8
Port_784297_2 | SOURCEANDSINK | ACIP 6
Port_784298_1 | SOURCEANDSINK | ACIP 6
InPort_784338_2 | SINK | ACIP 7
OutPort_784330_0 | SOURCE | ACIP 7
InPort_784330_1 | SINK | ACIP 7
InPort_784382_2 | SINK | ACIS 8
OutPort_784372_0 | SOURCE | ACIS 8
InPort_784372_1 | SINK | ACIS 8
Port_784432_0 | SOURCEANDSINK | ACIP 6
Port_784442_2 | SOURCEANDSINK | ACIP 6
Port_784432_1 | SOURCEANDSINK | ACIP 6
Port_784982_1 | SOURCEANDSINK | ACIP 6
Port_784504_0 | SOURCEANDSINK | ACIS 5
Port_784905_1 | SOURCEANDSINK | ACIS 5
Port_784504_1 | SOURCEANDSINK | ACIS 5
Port_784944_1 | SOURCEANDSINK | ACIS 5
InPort_784597_0 | SINK | AFIP 12
OutPort_784605_2 | SOURCE | AFIP 12
InPort_784597_1 | SINK | AFIP 12
Port_784624_0 | SOURCEANDSINK | AFIP 7
Port_784632_2 | SOURCEANDSINK | AFIP 7
Port_784624_1 | SOURCEANDSINK | AFIP 7
Port_784735_1 | SOURCEANDSINK | ACIP 6
Port_784884_1 | SOURCEANDSINK | ACIP 6
Port_784836_0 | SOURCEANDSINK | ACIS 5
Port_784912_1 | SOURCEANDSINK | ACIS 5
Port_784836_1 | SOURCEANDSINK | ACIS 5
Port_784914_1 | SOURCEANDSINK | ACIS 5
Port_784868_0 | SOURCEANDSINK | ACIP 6
Port_784884_2 | SOURCEANDSINK | ACIP 6
Port_784868_1 | SOURCEANDSINK | ACIP 6
Port_784886_1 | SOURCEANDSINK | ACIP 6
Port_784936_0 | SOURCEANDSINK | ACIS 5
Port_784944_2 | SOURCEANDSINK | ACIS 5
Port_784936_1 | SOURCEANDSINK | ACIS 5
Port_784974_0 | SOURCEANDSINK | ACIP 6
Port_784982_2 | SOURCEANDSINK | ACIP 6
Port_784974_1 | SOURCEANDSINK | ACIP 6
InPort_785139_0 | SINK | AI 21
OutPort_785150_2 | SOURCE | AI 21
InPort_785217_1 | SINK | AI 21
OutPort_785139_1 | SOURCE | AI 21
InPort_785154_0 | SINK | AI 21
OutPort_785217_2 | SOURCE | AI 21
InPort_785230_1 | SINK | AI 21
OutPort_785154_1 | SOURCE | AI 21
InPort_785221_0 | SINK | AI 21
OutPort_785230_2 | SOURCE | AI 21
InPort_785242_1 | SINK | AI 21
OutPort_785221_1 | SOURCE | AI 21
InPort_785234_1 | SINK | AI 21
OutPort_785242_2 | SOURCE | AI 21
Port_785265_0 | SOURCEANDSINK | ACIS 6
Port_785459_1 | SOURCEANDSINK | ACIS 6
Port_785265_1 | SOURCEANDSINK | ACIS 6
Port_785267_0 | SOURCEANDSINK | AFIS 7
Port_785880_1 | SOURCEANDSINK | AFIS 7
Port_785267_1 | SOURCEANDSINK | AFIS 7
Port_785269_0 | SOURCEANDSINK | AFIP 13
Port_785878_1 | SOURCEANDSINK | AFIP 13
Port_785269_1 | SOURCEANDSINK | AFIP 13
Port_785271_0 | SOURCEANDSINK | ACIP 8
Port_785271_1 | SOURCEANDSINK | ACIP 8
Port_786064_1 | SOURCEANDSINK | ACIP 8
Port_785451_0 | SOURCEANDSINK | ACIS 6
Port_785459_2 | SOURCEANDSINK | ACIS 6
Port_785451_1 | SOURCEANDSINK | ACIS 6
Port_786031_1 | SOURCEANDSINK | ACIS 6
Port_785510_0 | SOURCEANDSINK | AFIP 13
Port_785803_2 | SOURCEANDSINK | AFIP 13
Port_785510_1 | SOURCEANDSINK | AFIP 13
Port_785878_2 | SOURCEANDSINK | AFIP 13
Port_785577_0 | SOURCEANDSINK | AFIS 7
Port_785801_2 | SOURCEANDSINK | AFIS 7
Port_785577_1 | SOURCEANDSINK | AFIS 7
Port_785880_2 | SOURCEANDSINK | AFIS 7
Port_785781_0 | SOURCEANDSINK | AFIS 7
Port_785801_1 | SOURCEANDSINK | AFIS 7
Port_785781_1 | SOURCEANDSINK | AFIS 7
Port_785826_2 | SOURCEANDSINK | AFIS 7
Port_785803_1 | SOURCEANDSINK | AFIP 13
Port_785847_0 | SOURCEANDSINK | AFIP 13
Port_785818_0 | SOURCEANDSINK | AFIS 7
Port_785826_1 | SOURCEANDSINK | AFIS 7
Port_785818_1 | SOURCEANDSINK | AFIS 7
Port_785898_1 | SOURCEANDSINK | AFIS 7
Port_785847_1 | SOURCEANDSINK | AFIP 13
Port_785863_2 | SOURCEANDSINK | AFIP 13
Port_785855_0 | SOURCEANDSINK | AFIP 13
Port_785863_1 | SOURCEANDSINK | AFIP 13
Port_785855_1 | SOURCEANDSINK | AFIP 13
Port_785934_1 | SOURCEANDSINK | AFIP 13
Port_785890_0 | SOURCEANDSINK | AFIS 7
Port_785898_2 | SOURCEANDSINK | AFIS 7
Port_785890_1 | SOURCEANDSINK | AFIS 7
Port_785906_1 | SOURCEANDSINK | AFIS 7
Port_785900_0 | SOURCEANDSINK | AFIS 7
Port_785906_2 | SOURCEANDSINK | AFIS 7
Port_785900_1 | SOURCEANDSINK | AFIS 7
Port_785926_0 | SOURCEANDSINK | AFIP 13
Port_785934_2 | SOURCEANDSINK | AFIP 13
Port_785926_1 | SOURCEANDSINK | AFIP 13
Port_785942_1 | SOURCEANDSINK | AFIP 13
Port_785936_0 | SOURCEANDSINK | AFIP 13
Port_785942_2 | SOURCEANDSINK | AFIP 13
Port_785936_1 | SOURCEANDSINK | AFIP 13
Port_786023_0 | SOURCEANDSINK | ACIS 6
Port_786031_2 | SOURCEANDSINK | ACIS 6
Port_786023_1 | SOURCEANDSINK | ACIS 6
Port_786039_1 | SOURCEANDSINK | ACIS 6
Port_786033_0 | SOURCEANDSINK | ACIS 6
Port_786039_2 | SOURCEANDSINK | ACIS 6
Port_786033_1 | SOURCEANDSINK | ACIS 6
Port_786056_0 | SOURCEANDSINK | ACIP 8
Port_786064_2 | SOURCEANDSINK | ACIP 8
Port_786056_1 | SOURCEANDSINK | ACIP 8
Port_786074_1 | SOURCEANDSINK | ACIP 8
Port_786068_0 | SOURCEANDSINK | ACIP 8
Port_786074_2 | SOURCEANDSINK | ACIP 8
Port_786068_1 | SOURCEANDSINK | ACIP 8
InPort_786191_1 | SINK | ACIS 7
OutPort_786102_0 | SOURCE | ACIS 7
InPort_786102_1 | SINK | ACIS 7
Port_786104_0 | SOURCEANDSINK | AFIS 9
Port_786187_1 | SOURCEANDSINK | AFIS 9
Port_786104_1 | SOURCEANDSINK | AFIS 9
Port_786106_0 | SOURCEANDSINK | AFIP 14
Port_786185_1 | SOURCEANDSINK | AFIP 14
Port_786106_1 | SOURCEANDSINK | AFIP 14
Port_786108_0 | SOURCEANDSINK | ACIP 9
Port_786108_1 | SOURCEANDSINK | ACIP 9
Port_786189_1 | SOURCEANDSINK | ACIP 9
InPort_786156_0 | SINK | ACIS 7
OutPort_786191_2 | SOURCE | ACIS 7
InPort_786860_1 | SINK | ACIS 7
OutPort_786156_1 | SOURCE | ACIS 7
Port_786158_0 | SOURCEANDSINK | AFIS 9
Port_786187_2 | SOURCEANDSINK | AFIS 9
Port_786158_1 | SOURCEANDSINK | AFIS 9
Port_786231_2 | SOURCEANDSINK | AFIS 9
Port_786160_0 | SOURCEANDSINK | AFIP 14
Port_786185_2 | SOURCEANDSINK | AFIP 14
Port_786160_1 | SOURCEANDSINK | AFIP 14
Port_786255_2 | SOURCEANDSINK | AFIP 14
Port_786162_0 | SOURCEANDSINK | ACIP 9
Port_786189_2 | SOURCEANDSINK | ACIP 9
Port_786162_1 | SOURCEANDSINK | ACIP 9
Port_786885_1 | SOURCEANDSINK | ACIP 9
Port_786223_0 | SOURCEANDSINK | AFIS 9
Port_786231_1 | SOURCEANDSINK | AFIS 9
Port_786223_1 | SOURCEANDSINK | AFIS 9
Port_786547_2 | SOURCEANDSINK | AFIS 9
Port_786255_1 | SOURCEANDSINK | AFIP 14
Port_786485_0 | SOURCEANDSINK | AFIP 14
Port_786485_1 | SOURCEANDSINK | AFIP 14
Port_786507_2 | SOURCEANDSINK | AFIP 14
Port_786493_0 | SOURCEANDSINK | AFIP 14
Port_786507_1 | SOURCEANDSINK | AFIP 14
Port_786493_1 | SOURCEANDSINK | AFIP 14
Port_786804_1 | SOURCEANDSINK | AFIP 14
Port_786537_0 | SOURCEANDSINK | AFIS 9
Port_786547_1 | SOURCEANDSINK | AFIS 9
Port_786537_1 | SOURCEANDSINK | AFIS 9
Port_786748_1 | SOURCEANDSINK | AFIS 9
Port_786736_0 | SOURCEANDSINK | AFIS 9
Port_786748_2 | SOURCEANDSINK | AFIS 9
Port_786736_1 | SOURCEANDSINK | AFIS 9
Port_786759_1 | SOURCEANDSINK | AFIS 9
Port_786750_0 | SOURCEANDSINK | AFIS 9
Port_786759_2 | SOURCEANDSINK | AFIS 9
Port_786750_1 | SOURCEANDSINK | AFIS 9
Port_786796_0 | SOURCEANDSINK | AFIP 14
Port_786804_2 | SOURCEANDSINK | AFIP 14
Port_786796_1 | SOURCEANDSINK | AFIP 14
Port_786812_1 | SOURCEANDSINK | AFIP 14
Port_786806_0 | SOURCEANDSINK | AFIP 14
Port_786812_2 | SOURCEANDSINK | AFIP 14
Port_786806_1 | SOURCEANDSINK | AFIP 14
InPort_786860_2 | SINK | ACIS 7
OutPort_786850_0 | SOURCE | ACIS 7
InPort_786850_1 | SINK | ACIP 10
Port_786875_0 | SOURCEANDSINK | ACIP 9
Port_786885_2 | SOURCEANDSINK | ACIP 9
Port_786875_1 | SOURCEANDSINK | ACIP 9
Port_786912_1 | SOURCEANDSINK | ACIP 9
Port_786904_0 | SOURCEANDSINK | ACIP 9
Port_786912_2 | SOURCEANDSINK | ACIP 9
Port_786904_1 | SOURCEANDSINK | ACIP 9
Port_786929_0 | SOURCEANDSINK | ACIP 11
Port_786929_1 | SOURCEANDSINK | ACIP 11
Port_786980_1 | SOURCEANDSINK | ACIP 11
Port_786969_0 | SOURCEANDSINK | ACIP 11
Port_786980_2 | SOURCEANDSINK | ACIP 11
Port_786969_1 | SOURCEANDSINK | ACIP 11
Port_787676_0 | SOURCEANDSINK | AFIS 10
Port_788034_1 | SOURCEANDSINK | AFIS 10
Port_787676_1 | SOURCEANDSINK | AFIS 10
Port_787678_0 | SOURCEANDSINK | AFIP 16
Port_787847_1 | SOURCEANDSINK | AFIP 16
Port_787678_1 | SOURCEANDSINK | AFIP 16
Port_787717_0 | SOURCEANDSINK | ACIS 9
Port_787851_2 | SOURCEANDSINK | ACIS 9
Port_787717_1 | SOURCEANDSINK | ACIS 9
Port_787719_0 | SOURCEANDSINK | ACIP 12
Port_788199_1 | SOURCEANDSINK | ACIP 12
Port_787719_1 | SOURCEANDSINK | ACIP 12
Port_787748_0 | SOURCEANDSINK | ACIS 9
Port_788175_1 | SOURCEANDSINK | ACIS 9
Port_787748_1 | SOURCEANDSINK | ACIS 9
Port_787851_1 | SOURCEANDSINK | ACIS 9
Port_787750_0 | SOURCEANDSINK | ACIP 12
Port_788199_2 | SOURCEANDSINK | ACIP 12
Port_787750_1 | SOURCEANDSINK | ACIP 12
Port_788225_1 | SOURCEANDSINK | ACIP 12
Port_787791_0 | SOURCEANDSINK | AFIP 16
Port_787847_2 | SOURCEANDSINK | AFIP 16
Port_787791_1 | SOURCEANDSINK | AFIP 16
Port_787913_1 | SOURCEANDSINK | AFIP 16
Port_787905_0 | SOURCEANDSINK | AFIP 16
Port_787913_2 | SOURCEANDSINK | AFIP 16
Port_787905_1 | SOURCEANDSINK | AFIP 16
Port_788139_1 | SOURCEANDSINK | AFIP 16
Port_787930_0 | SOURCEANDSINK | AFIS 10
Port_788034_2 | SOURCEANDSINK | AFIS 10
Port_787930_1 | SOURCEANDSINK | AFIS 10
Port_788078_1 | SOURCEANDSINK | AFIS 10
Port_788067_0 | SOURCEANDSINK | AFIS 10
Port_788078_2 | SOURCEANDSINK | AFIS 10
Port_788067_1 | SOURCEANDSINK | AFIS 10
Port_788131_0 | SOURCEANDSINK | AFIP 16
Port_788139_2 | SOURCEANDSINK | AFIP 16
Port_788131_1 | SOURCEANDSINK | AFIP 16
Port_788167_0 | SOURCEANDSINK | ACIS 9
Port_788175_2 | SOURCEANDSINK | ACIS 9
Port_788167_1 | SOURCEANDSINK | ACIS 9
Port_788250_1 | SOURCEANDSINK | ACIS 9
Port_788217_0 | SOURCEANDSINK | ACIP 12
Port_788225_2 | SOURCEANDSINK | ACIP 12
Port_788217_1 | SOURCEANDSINK | ACIP 12
Port_788242_0 | SOURCEANDSINK | ACIS 9
Port_788250_2 | SOURCEANDSINK | ACIS 9
Port_788242_1 | SOURCEANDSINK | ACIS 9
Port_788529_0 | SOURCEANDSINK | ACIS 10
Port_788941_1 | SOURCEANDSINK | ACIS 10
Port_788529_1 | SOURCEANDSINK | ACIS 10
InPort_788674_1 | SINK | AFIS 11
OutPort_788531_0 | SOURCE | AFIS 11
InPort_788531_1 | SINK | AFIS 11
Port_788533_0 | SOURCEANDSINK | AFIP 15
Port_788672_1 | SOURCEANDSINK | AFIP 15
Port_788533_1 | SOURCEANDSINK | AFIP 15
Port_788535_0 | SOURCEANDSINK | ACIP 13
Port_788937_1 | SOURCEANDSINK | ACIP 13
Port_788535_1 | SOURCEANDSINK | ACIP 13
Port_788638_0 | SOURCEANDSINK | ACIS 10
Port_789352_1 | SOURCEANDSINK | ACIS 10
Port_788638_1 | SOURCEANDSINK | ACIS 10
Port_788941_2 | SOURCEANDSINK | ACIS 10
InPort_788640_0 | SINK | AFIS 11
OutPort_788674_2 | SOURCE | AFIS 11
InPort_788983_1 | SINK | AFIS 11
OutPort_788640_1 | SOURCE | AFIS 11
Port_788642_0 | SOURCEANDSINK | AFIP 15
Port_788672_2 | SOURCEANDSINK | AFIP 15
Port_788642_1 | SOURCEANDSINK | AFIP 15
Port_789021_1 | SOURCEANDSINK | AFIP 15
Port_788644_0 | SOURCEANDSINK | ACIP 13
Port_789348_1 | SOURCEANDSINK | ACIP 13
Port_788644_1 | SOURCEANDSINK | ACIP 13
Port_788937_2 | SOURCEANDSINK | ACIP 13
InPort_788975_0 | SINK | AFIP 17
OutPort_788983_2 | SOURCE | AFIP 17
InPort_788975_1 | SINK | AFIP 17
OutPort_788994_1 | SOURCE | AFIP 17
InPort_788994_2 | SINK | AFIP 17
OutPort_788988_0 | SOURCE | AFIP 17
InPort_788988_1 | SINK | AFIP 17
Port_789013_0 | SOURCEANDSINK | AFIP 15
Port_789021_2 | SOURCEANDSINK | AFIP 15
Port_789013_1 | SOURCEANDSINK | AFIP 15
Port_789031_1 | SOURCEANDSINK | AFIP 15
Port_789025_0 | SOURCEANDSINK | AFIP 15
Port_789031_2 | SOURCEANDSINK | AFIP 15
Port_789025_1 | SOURCEANDSINK | AFIP 15
Port_789070_0 | SOURCEANDSINK | ACIP 13
Port_789701_1 | SOURCEANDSINK | ACIP 13
Port_789070_1 | SOURCEANDSINK | ACIP 13
Port_789129_1 | SOURCEANDSINK | ACIP 13
Port_789080_0 | SOURCEANDSINK | ACIP 13
Port_789129_2 | SOURCEANDSINK | ACIP 13
Port_789080_1 | SOURCEANDSINK | ACIP 13
Port_789139_0 | SOURCEANDSINK | ACIS 10
Port_789689_1 | SOURCEANDSINK | ACIS 10
Port_789139_1 | SOURCEANDSINK | ACIS 10
Port_789155_1 | SOURCEANDSINK | ACIS 10
Port_789149_0 | SOURCEANDSINK | ACIS 10
Port_789155_2 | SOURCEANDSINK | ACIS 10
Port_789149_1 | SOURCEANDSINK | ACIS 10
Port_789334_0 | SOURCEANDSINK | ACIS 10
Port_789352_2 | SOURCEANDSINK | ACIS 10
Port_789334_1 | SOURCEANDSINK | ACIS 10
Port_789696_2 | SOURCEANDSINK | ACIS 10
Port_789336_0 | SOURCEANDSINK | ACIP 13
Port_789348_2 | SOURCEANDSINK | ACIP 13
Port_789336_1 | SOURCEANDSINK | ACIP 13
Port_789705_2 | SOURCEANDSINK | ACIP 13
Port_789415_0 | SOURCEANDSINK | ACIS 10
Port_789689_2 | SOURCEANDSINK | ACIS 10
Port_789415_1 | SOURCEANDSINK | ACIS 10
Port_789696_1 | SOURCEANDSINK | ACIS 10
Port_789454_0 | SOURCEANDSINK | ACIP 13
Port_789701_2 | SOURCEANDSINK | ACIP 13
Port_789454_1 | SOURCEANDSINK | ACIP 13
Port_789705_1 | SOURCEANDSINK | ACIP 13
Port_789718_0 | SOURCEANDSINK | ACIS 11
Port_790218_1 | SOURCEANDSINK | ACIS 11
Port_789718_1 | SOURCEANDSINK | ACIS 11
InPort_790300_1 | SINK | AFIS 12
OutPort_789720_0 | SOURCE | AFIS 12
InPort_789720_1 | SINK | AFIS 12
Port_789722_0 | SOURCEANDSINK | AFIP 18
Port_790302_1 | SOURCEANDSINK | AFIP 18
Port_789722_1 | SOURCEANDSINK | AFIP 18
Port_789724_0 | SOURCEANDSINK | ACIP 14
Port_790216_1 | SOURCEANDSINK | ACIP 14
Port_789724_1 | SOURCEANDSINK | ACIP 14
InPort_790108_1 | SINK | AI 22
OutPort_789895_0 | SOURCE | AI 22
InPort_789895_1 | SINK | AI 22
OutPort_790013_1 | SOURCE | AI 22
InPort_789941_1 | SINK | AI 22
OutPort_790106_1 | SOURCE | AI 22
InPort_789995_0 | SINK | AI 22
OutPort_790010_2 | SOURCE | AI 22
InPort_790013_2 | SINK | AI 22
OutPort_789995_1 | SOURCE | AI 22
InPort_790106_2 | SINK | AI 22
OutPort_790092_0 | SOURCE | AI 22
InPort_790092_1 | SINK | AI 22
OutPort_790108_2 | SOURCE | AI 22
Port_790189_0 | SOURCEANDSINK | ACIS 11
Port_790577_1 | SOURCEANDSINK | ACIS 11
Port_790189_1 | SOURCEANDSINK | ACIS 11
Port_790218_2 | SOURCEANDSINK | ACIS 11
Port_790191_0 | SOURCEANDSINK | ACIP 14
Port_790216_2 | SOURCEANDSINK | ACIP 14
Port_790191_1 | SOURCEANDSINK | ACIP 14
Port_790631_1 | SOURCEANDSINK | ACIP 14
InPort_790265_0 | SINK | AFIS 12
OutPort_790300_2 | SOURCE | AFIS 12
InPort_790358_2 | SINK | AFIS 12
OutPort_790265_1 | SOURCE | AFIS 12
Port_790267_0 | SOURCEANDSINK | AFIP 18
Port_790302_2 | SOURCEANDSINK | AFIP 18
Port_790267_1 | SOURCEANDSINK | AFIP 18
Port_790424_2 | SOURCEANDSINK | AFIP 18
InPort_790317_0 | SINK | AFIS 12
OutPort_790390_2 | SOURCE | AFIS 12
InPort_790477_1 | SINK | AFIS 12
OutPort_790317_1 | SOURCE | AFIS 12
Port_790319_0 | SOURCEANDSINK | AFIP 18
Port_790432_2 | SOURCEANDSINK | AFIP 18
Port_790319_1 | SOURCEANDSINK | AFIP 18
Port_790516_1 | SOURCEANDSINK | AFIP 18
InPort_790350_0 | SINK | AFIS 12
OutPort_790358_1 | SOURCE | AFIS 12
InPort_790390_1 | SINK | AFIS 12
OutPort_790350_1 | SOURCE | AFIS 12
Port_790416_0 | SOURCEANDSINK | AFIP 18
Port_790424_1 | SOURCEANDSINK | AFIP 18
Port_790416_1 | SOURCEANDSINK | AFIP 18
Port_790432_1 | SOURCEANDSINK | AFIP 18
InPort_790469_0 | SINK | AFIP 19
OutPort_790477_2 | SOURCE | AFIP 19
InPort_790469_1 | SINK | AFIP 19
OutPort_790486_1 | SOURCE | AFIP 19
InPort_790486_2 | SINK | AFIP 19
OutPort_790480_0 | SOURCE | AFIP 19
InPort_790480_1 | SINK | AFIP 19
Port_790508_0 | SOURCEANDSINK | AFIP 18
Port_790516_2 | SOURCEANDSINK | AFIP 18
Port_790508_1 | SOURCEANDSINK | AFIP 18
Port_790555_1 | SOURCEANDSINK | AFIP 18
Port_790518_0 | SOURCEANDSINK | AFIP 18
Port_790555_2 | SOURCEANDSINK | AFIP 18
Port_790518_1 | SOURCEANDSINK | AFIP 18
Port_790569_0 | SOURCEANDSINK | ACIS 11
Port_790577_2 | SOURCEANDSINK | ACIS 11
Port_790569_1 | SOURCEANDSINK | ACIS 11
Port_790585_1 | SOURCEANDSINK | ACIS 11
Port_790579_0 | SOURCEANDSINK | ACIS 11
Port_790585_2 | SOURCEANDSINK | ACIS 11
Port_790579_1 | SOURCEANDSINK | ACIS 11
Port_790623_0 | SOURCEANDSINK | ACIP 14
Port_790631_2 | SOURCEANDSINK | ACIP 14
Port_790623_1 | SOURCEANDSINK | ACIP 14
Port_790639_1 | SOURCEANDSINK | ACIP 14
Port_790633_0 | SOURCEANDSINK | ACIP 14
Port_790639_2 | SOURCEANDSINK | ACIP 14
Port_790633_1 | SOURCEANDSINK | ACIP 14
Port_790676_0 | SOURCEANDSINK | ACIP 15
Port_791115_1 | SOURCEANDSINK | ACIP 15
Port_790676_1 | SOURCEANDSINK | ACIP 15
Port_790678_0 | SOURCEANDSINK | AFIS 13
Port_790812_1 | SOURCEANDSINK | AFIS 13
Port_790678_1 | SOURCEANDSINK | AFIS 13
Port_790680_0 | SOURCEANDSINK | AFIP 20
Port_790944_1 | SOURCEANDSINK | AFIP 20
Port_790680_1 | SOURCEANDSINK | AFIP 20
Port_790781_0 | SOURCEANDSINK | AFIP 20
Port_790946_1 | SOURCEANDSINK | AFIP 20
Port_790781_1 | SOURCEANDSINK | AFIP 20
Port_790970_1 | SOURCEANDSINK | AFIP 20
Port_790804_0 | SOURCEANDSINK | AFIS 13
Port_790812_2 | SOURCEANDSINK | AFIS 13
Port_790804_1 | SOURCEANDSINK | AFIS 13
Port_790876_1 | SOURCEANDSINK | AFIS 13
Port_790868_0 | SOURCEANDSINK | AFIS 13
Port_790876_2 | SOURCEANDSINK | AFIS 13
Port_790868_1 | SOURCEANDSINK | AFIS 13
Port_790912_0 | SOURCEANDSINK | AFIP 20
Port_790944_2 | SOURCEANDSINK | AFIP 20
Port_790912_1 | SOURCEANDSINK | AFIP 20
Port_790946_2 | SOURCEANDSINK | AFIP 20
Port_790960_0 | SOURCEANDSINK | AFIP 20
Port_790970_2 | SOURCEANDSINK | AFIP 20
Port_790960_1 | SOURCEANDSINK | AFIP 20
Port_791067_0 | SOURCEANDSINK | ACIS 12
Port_791067_1 | SOURCEANDSINK | ACIS 12
Port_791085_2 | SOURCEANDSINK | ACIS 12
Port_791075_0 | SOURCEANDSINK | ACIS 12
Port_791085_1 | SOURCEANDSINK | ACIS 12
Port_791075_1 | SOURCEANDSINK | ACIS 12
Port_791137_1 | SOURCEANDSINK | ACIS 12
Port_791105_0 | SOURCEANDSINK | ACIP 15
Port_791115_2 | SOURCEANDSINK | ACIP 15
Port_791105_1 | SOURCEANDSINK | ACIP 15
Port_791185_1 | SOURCEANDSINK | ACIP 15
Port_791129_0 | SOURCEANDSINK | ACIS 12
Port_791137_2 | SOURCEANDSINK | ACIS 12
Port_791129_1 | SOURCEANDSINK | ACIS 12
Port_791149_1 | SOURCEANDSINK | ACIS 12
Port_791141_0 | SOURCEANDSINK | ACIS 12
Port_791149_2 | SOURCEANDSINK | ACIS 12
Port_791141_1 | SOURCEANDSINK | ACIS 12
Port_791179_0 | SOURCEANDSINK | ACIP 15
Port_791185_2 | SOURCEANDSINK | ACIP 15
Port_791179_1 | SOURCEANDSINK | ACIP 15
Port_791245_0 | SOURCEANDSINK | ACIP 16
Port_791255_1 | SOURCEANDSINK | ACIP 16
Port_791245_1 | SOURCEANDSINK | ACIP 16
Port_791247_0 | SOURCEANDSINK | ACIS 13
Port_791247_1 | SOURCEANDSINK | ACIS 13
Port_791251_2 | SOURCEANDSINK | ACIS 13
Port_791249_0 | SOURCEANDSINK | ACIS 13
Port_791251_1 | SOURCEANDSINK | ACIS 13
Port_791249_1 | SOURCEANDSINK | ACIS 13
Port_791259_1 | SOURCEANDSINK | ACIS 13
Port_791253_0 | SOURCEANDSINK | ACIP 16
Port_791255_2 | SOURCEANDSINK | ACIP 16
Port_791253_1 | SOURCEANDSINK | ACIP 16
Port_791267_1 | SOURCEANDSINK | ACIP 16
Port_791257_0 | SOURCEANDSINK | ACIS 13
Port_791259_2 | SOURCEANDSINK | ACIS 13
Port_791257_1 | SOURCEANDSINK | ACIS 13
Port_791263_1 | SOURCEANDSINK | ACIS 13
Port_791261_0 | SOURCEANDSINK | ACIS 13
Port_791263_2 | SOURCEANDSINK | ACIS 13
Port_791261_1 | SOURCEANDSINK | ACIS 13
Port_791265_0 | SOURCEANDSINK | ACIP 16
Port_791267_2 | SOURCEANDSINK | ACIP 16
Port_791265_1 | SOURCEANDSINK | ACIP 16
Port_791312_0 | SOURCEANDSINK | AFIS 14
Port_791320_1 | SOURCEANDSINK | AFIS 14
Port_791312_1 | SOURCEANDSINK | AFIS 14
Port_791314_0 | SOURCEANDSINK | AFIP 21
Port_791324_1 | SOURCEANDSINK | AFIP 21
Port_791314_1 | SOURCEANDSINK | AFIP 21
Port_791316_0 | SOURCEANDSINK | AFIP 21
Port_791326_1 | SOURCEANDSINK | AFIP 21
Port_791316_1 | SOURCEANDSINK | AFIP 21
Port_791318_0 | SOURCEANDSINK | AFIS 14
Port_791320_2 | SOURCEANDSINK | AFIS 14
Port_791318_1 | SOURCEANDSINK | AFIS 14
Port_791322_0 | SOURCEANDSINK | AFIP 21
Port_791324_2 | SOURCEANDSINK | AFIP 21
Port_791322_1 | SOURCEANDSINK | AFIP 21
Port_791326_2 | SOURCEANDSINK | AFIP 21
InPort_793675_3 | SINK | AFS 4
OutPort_793669_0 | SOURCE | AFS 4
InPort_793669_1 | SINK | AFS 4
InPort_793676_0 | SINK | AFS 4
OutPort_793675_4 | SOURCE | AFS 4
InPort_794545_1 | SINK | AFS 4
OutPort_793676_1 | SOURCE | AFS 4
InPort_795445_1 | SINK | SAN_Fecal Aeri 2
OutPort_793777_1 | SOURCE | SAN_Fecal Aeri 2
InPort_793777_2 | SINK | AFS 4
OutPort_794658_0 | SOURCE | AFS 4
InPort_794537_0 | SINK | AFS 4
OutPort_794545_2 | SOURCE | AFS 4
InPort_794670_2 | SINK | AFS 4
OutPort_794537_1 | SOURCE | AFS 4
InPort_794621_0 | SINK | AFS 4
OutPort_794670_1 | SOURCE | AFS 4
InPort_794672_2 | SINK | AFS 4
OutPort_794621_1 | SOURCE | AFS 4
InPort_794658_1 | SINK | AFS 4
OutPort_794662_1 | SOURCE | AFS 4
InPort_794662_2 | SINK | AFS 4
OutPort_794659_0 | SOURCE | AFS 4
InPort_794659_1 | SINK | AFS 4
OutPort_794672_1 | SOURCE | AFS 4
InPort_795310_1 | SINK | AFS 2
OutPort_794744_0 | SOURCE | AFS 2
InPort_795217_0 | SINK | AFS 2
OutPort_795225_3 | SOURCE | AFS 2
InPort_795318_1 | SINK | AFS 2
OutPort_795217_1 | SOURCE | AFS 2
InPort_795225_2 | SINK | AFS 2
OutPort_795226_1 | SOURCE | AFS 2
InPort_795226_0 | SINK | AFS 2
OutPort_795310_2 | SOURCE | AFS 2
InPort_795256_1 | SINK | AFS 2
OutPort_795260_1 | SOURCE | AFS 2
InPort_795260_2 | SINK | AFS 2
OutPort_795257_0 | SOURCE | AFS 2
InPort_795257_1 | SINK | AFS 2
OutPort_795270_1 | SOURCE | AFS 2
InPort_795359_0 | SINK | AFS 2
OutPort_795409_1 | SOURCE | AFS 2
InPort_795411_2 | SINK | AFS 2
OutPort_795359_1 | SOURCE | AFS 2
InPort_795397_1 | SINK | AFS 2
OutPort_795401_1 | SOURCE | AFS 2
InPort_795401_2 | SINK | AFS 2
OutPort_795398_0 | SOURCE | AFS 2
InPort_795398_1 | SINK | AFS 2
OutPort_795411_1 | SOURCE | AFS 2
InPort_795432_0 | SINK | SAN_Fecal Aeri 2
OutPort_795445_2 | SOURCE | SAN_Fecal Aeri 2
InPort_795460_1 | SINK | SAN_Fecal Aeri 2
OutPort_795432_1 | SOURCE | SAN_Fecal Aeri 2
InPort_795448_0 | SINK | SAN_Fecal Aeri 2
OutPort_795460_2 | SOURCE | SAN_Fecal Aeri 2
InPort_795470_1 | SINK | SAN_Fecal Aeri 2
OutPort_795448_1 | SOURCE | SAN_Fecal Aeri 2
InPort_795462_0 | SINK | SAN_Fecal Aeri 2
OutPort_795470_2 | SOURCE | SAN_Fecal Aeri 2
InPort_795553_2 | SINK | SAN_Fecal Aeri 2
OutPort_795462_1 | SOURCE | SAN_Fecal Aeri 2
InPort_795542_0 | SINK | SAN_Fecal Aeri 2
OutPort_795732_2 | SOURCE | SAN_Fecal Aeri 2
OutPort_795542_1 | SOURCE | SAN_Fecal Aeri 2
InPort_795732_1 | SINK | SAN_Fecal Aeri 2
OutPort_795553_1 | SOURCE | SAN_Fecal Aeri 2
InPort_796781_2 | SINK | ASP 2
OutPort_796721_1 | SOURCE | ASP 2
InPort_805917_0 | SINK | ASP 2
OutPort_796780_1 | SOURCE | ASP 2
InPort_797654_0 | SINK | ASP 3
OutPort_808465_2 | SOURCE | ASP 3
InPort_808094_1 | SINK | ASP 3
OutPort_797654_1 | SOURCE | ASP 3
InPort_797948_0 | SINK | ASP 3
OutPort_797988_2 | SOURCE | ASP 3
InPort_808364_2 | SINK | ASP 3
OutPort_797948_1 | SOURCE | ASP 3
InPort_798166_0 | SINK | ASP 3
OutPort_797957_1 | SOURCE | ASP 3
InPort_797957_2 | SINK | ASP 3
OutPort_805365_0 | SOURCE | ASP 3
InPort_797988_1 | SINK | ASP 3
OutPort_797957_3 | SOURCE | ASP 3
InPort_797998_0 | SINK | ASP 1
OutPort_808386_2 | SOURCE | ASP 1
InPort_808159_2 | SINK | ASP 3
OutPort_797998_1 | SOURCE | ASP 3
InPort_808465_1 | SINK | ASP 3
OutPort_798166_1 | SOURCE | ASP 3
InPort_808386_1 | SINK | ASP 1
OutPort_798386_1 | SOURCE | ASP 1
InPort_798466_2 | SINK | ASP 1
OutPort_798457_0 | SOURCE | ASP 1
InPort_798457_1 | SINK | ASP 1
OutPort_798480_1 | SOURCE | ASP 1
InPort_798480_2 | SINK | ASP 1
OutPort_798471_1 | SOURCE | ASP 1
InPort_802418_1 | SINK
OutPort_802418_2 | SOURCE
OutPort_802418_3 | SOURCE
OutPort_802418_4 | SOURCE
InPort_803923_1 | SINK | ASP 4
OutPort_802418_5 | SOURCE | ASP 4
InPort_802631_1 | SINK
OutPort_802631_2 | SOURCE
OutPort_802631_3 | SOURCE
OutPort_802631_4 | SOURCE
InPort_806807_1 | SINK | ASP 3
OutPort_802631_5 | SOURCE | ASP 3
InPort_803886_0 | SINK | ASP 4
OutPort_803923_2 | SOURCE | ASP 4
InPort_804003_1 | SINK | ASP 4
OutPort_803886_1 | SOURCE | ASP 4
InPort_803958_0 | SINK | ASP 4
OutPort_804003_2 | SOURCE | ASP 4
InPort_804014_2 | SINK | ASP 4
OutPort_803958_1 | SOURCE | ASP 4
InPort_804007_0 | SINK | ASP 4
OutPort_804174_1 | SOURCE | ASP 4
InPort_804239_1 | SINK | ASP 4
OutPort_804007_1 | SOURCE | ASP 4
InPort_804174_2 | SINK | ASP 4
OutPort_804014_1 | SOURCE | ASP 4
InPort_804227_0 | SINK | ASP 4
OutPort_804239_2 | SOURCE | ASP 4
InPort_806513_1 | SINK | ASP 4
OutPort_804227_1 | SOURCE | ASP 4
InPort_804840_1 | SINK | AE 3
OutPort_804519_0 | SOURCE | AE 3
InPort_804519_1 | SINK | AE 3
OutPort_805173_2 | SOURCE | AE 3
InPort_804805_1 | SINK | AE 3
OutPort_804675_1 | SOURCE | AE 3
InPort_804805_0 | SINK | AE 3
OutPort_804840_2 | SOURCE | AE 3
InPort_804675_1 | SINK | AE 3
OutPort_804805_1 | SOURCE | AE 3
InPort_805165_0 | SINK | AEWC 2
OutPort_804973_2 | SOURCE | AEWC 2
InPort_805148_0 | SINK | AE 3
OutPort_805170_2 | SOURCE | AE 3
InPort_805173_1 | SINK | AE 3
OutPort_805148_1 | SOURCE | AE 3
InPort_805164_1 | SINK | AEWC 2
OutPort_805165_1 | SOURCE | AEWC 2
InPort_805164_3 | SINK | AEWC 2
OutPort_805170_1 | SOURCE | AEWC 2
InPort_805365_1 | SINK | ASP 3
OutPort_807234_2 | SOURCE | ASP 3
InPort_806301_2 | SINK | ASP 4
OutPort_805917_1 | SOURCE | ASP 4
InPort_806075_0 | SINK | ASP 4
OutPort_806513_2 | SOURCE | ASP 4
InPort_806301_1 | SINK | ASP 4
OutPort_806075_1 | SOURCE | ASP 4
InPort_806766_0 | SINK | ASP 3
OutPort_806807_2 | SOURCE | ASP 3
InPort_806837_1 | SINK | ASP 3
OutPort_806766_1 | SOURCE | ASP 3
InPort_806858_0 | SINK | ASP 3
OutPort_806837_2 | SOURCE | ASP 3
InPort_806874_2 | SINK | ASP 3
OutPort_806858_1 | SOURCE | ASP 3
InPort_806940_0 | SINK | ASP 3
OutPort_806874_1 | SOURCE | ASP 3
InPort_807513_1 | SINK | ASP 3
OutPort_806940_1 | SOURCE | ASP 3
InPort_807234_1 | SINK | ASP 3
OutPort_807707_1 | SOURCE | ASP 3
InPort_807684_0 | SINK | ASP 3
OutPort_807513_2 | SOURCE | ASP 3
InPort_807702_1 | SINK | ASP 3
OutPort_807684_1 | SOURCE | ASP 3
InPort_807691_0 | SINK | ASP 3
OutPort_807702_2 | SOURCE | ASP 3
InPort_807740_1 | SINK | ASP 3
OutPort_807691_1 | SOURCE | ASP 3
InPort_807707_0 | SINK | ASP 3
OutPort_807740_2 | SOURCE | ASP 3
InPort_807990_0 | SINK | ASP 3
OutPort_808364_1 | SOURCE | ASP 3
InPort_808159_1 | SINK | ASP 3
OutPort_807990_1 | SOURCE | ASP 3
InPort_808015_0 | SINK | ASP 1
OutPort_808485_2 | SOURCE | ASP 1
InPort_808094_2 | SINK | ASP 3
OutPort_808015_1 | SOURCE | ASP 3

# IfcFlowController: ZYR_15.01.01 Vàlvula Tall:Vàlvula FON (3)
Type - Material: Aluminio - STH - Pulido, Paint - STH - Palanca Azul, Latón - STH - Acabado Niquelado
Classification: 50.10.20.10 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Vàlvula FON; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Vàlvula FON; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Volum: 0.0000392733 m3
Name (ZYR_15.01.01 Vàlvula Tall:Vàlvula FON:...) | In | Group
695173 | P00 - SECTORITZACIÓ I EVACUACIÓ | AFS 3
695228 | P0A - SECTORITZACIÓ I EVACUACIÓ | AFS 2
793675 | P0A - SECTORITZACIÓ I EVACUACIÓ | AFS 4

# IfcFlowFitting: MEP_15.03 Injerto Conducte:Mínimo (186)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Mínimo; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Mínimo; ICAT_04-EstatusObra: Nueva construcción
Name (MEP_15.03 Injerto Conducte:Mínimo:...) | In | ICAT-Volum (m3) | Group
395368 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00547177 | ASP 2
397359 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.00428512 | ASP 1
398122 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.00138443 | ASP 1
406200 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00565637 | ASP 5
406267 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00565637 | ASP 5
424790 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.00356786 | AEPK 1
424825 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.00356786 | AEPK 1
434898 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.00356786 | AEPK 1
436277 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.00356786 | AEPK 1
473683 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 23
474506 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 23
474812 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 23
474994 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 23
475102 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 23
475402 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 23
475434 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 23
475464 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 23
475623 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 23
476871 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 31
478372 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 31
478749 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 13
478898 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 33
479115 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 33
479309 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 14
479460 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 14
479613 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00112073 | Mecánica Aire de retorno 15
479798 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00112073 | Mecánica Aire de retorno 15
480115 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 23
480254 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 16
480464 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 17
480699 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 17
480980 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00112073 | Mecánica Aire de retorno 17
483370 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | AI 23
484342 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 21
484613 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 21
484661 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 21
484844 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 21
485018 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 21
485288 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 21
485592 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 21
486171 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00084384 | AI 21
486423 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 21
490462 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 21
490641 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 21
490932 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 21
491197 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 19
491353 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 19
491612 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00112073 | Mecánica Aire de retorno 7
491801 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00112073 | Mecánica Aire de retorno 7
492291 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00112073 | Mecánica Aire de retorno 8
492615 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 8
492796 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 8
493152 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 8
493270 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00112073 | Mecánica Aire de retorno 8
493628 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 12
493763 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 11
493867 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 10
494113 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 11
494219 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 12
494265 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 8
494299 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 10
494420 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 8
497141 | Nivel 1 | 0.0013185 | AI 19
497213 | Nivel 1 | 0.0013185 | AI 19
497241 | Nivel 1 | 0.0013185 | AI 19
497375 | Nivel 1 | 0.0013185 | AI 19
497405 | Nivel 1 | 0.0013185 | AI 19
497437 | Nivel 1 | 0.0013185 | AI 19
498088 | Nivel 1 | 0.0013185 | AI 19
498261 | Nivel 1 | 0.0013185 | AI 19
498482 | Nivel 1 | 0.00084384 | AI 19
500594 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 20
500888 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 9
501151 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 34
501395 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 35
501476 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 36
501614 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 37
501678 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 38
501801 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 39
501860 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 40
501961 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 41
502364 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 37
502550 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 34
502723 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 36
502760 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 35
502797 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 38
502826 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 39
502855 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 40
502946 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 9
503032 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 20
503365 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 41
503691 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 64
503795 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 63
504018 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 64
504064 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 63
504193 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 62
504355 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 62
504460 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 61
504611 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 61
504735 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 43
504813 | Nivel 1 | 0.000593325 | Mecánica Aire de retorno 43
505347 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 18
505378 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 18
505412 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0013482 | AI 18
505447 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 18
505664 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 18
505692 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00136366 | AI 18
505723 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 18
505802 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 18
506027 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00084384 | AI 18
506271 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 18
506303 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 18
506496 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 18
507304 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 53
507460 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 29
507708 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 29
507734 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 53
507882 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 30
508217 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 27
508438 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 27
508668 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 30
509035 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00112073 | Mecánica Aire de retorno 54
509166 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00112073 | Mecánica Aire de retorno 54
509558 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00084384 | AI 22
509586 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00084384 | AI 22
509614 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00084384 | AI 22
509736 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
509844 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
510466 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
511051 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
511180 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
511817 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
511818 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
512002 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
512034 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
512250 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
512866 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
513017 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
513140 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
513168 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 22
514359 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00154265 | Mecánica Aire de retorno 4
514639 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 3
514807 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00154265 | Mecánica Aire de retorno 4
514895 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00154265 | Mecánica Aire de retorno 28
514899 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00154265 | Mecánica Aire de retorno 28
515104 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00112073 | Mecánica Aire de retorno 5
515398 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00112073 | Mecánica Aire de retorno 5
515551 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00154265 | Mecánica Aire de retorno 1
515784 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00154265 | Mecánica Aire de retorno 1
516095 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 3
516691 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 24
516721 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 24
516770 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 24
516971 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 24
516999 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 24
517028 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 24
517238 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00132275 | AI 24
517266 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00132275 | AI 24
517294 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 24
518515 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 55
518782 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 55
518842 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 55
519752 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.00739679 | Mecánica Aire Aportació PK EI 2
519779 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.00739679 | Mecánica Aire Aportació PK EI 2
519806 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.00739679 | Mecánica Aire Aportació PK EI 2
519833 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.00739679 | Mecánica Aire Aportació PK EI 2
659541 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 24
659555 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 24
659910 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 24
757284 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 23
757368 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 42
757593 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 22
757759 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.000593325 | Mecánica Aire de retorno 21
758757 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.00217553 | ASP 5
758972 | PS2 - SECTORITZACIÓ I EVACUACIÓ | 0.00217553 | ASP 5
759213 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00428512 | ASP 1
759472 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00428512 | ASP 2
759543 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00428512 | ASP 2
759616 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00428512 | ASP 2
759681 | Nivel 1 | 0.00428512 | ASP 2
759806 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00428512 | ASP 2
764616 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00222827 | AE 2
764890 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00154265 | AP 1
767288 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00565637 | AI 25
768031 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00565636 | Mecánica Aire de retorno 45
771489 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0013185 | AI 24

# IfcFlowFitting: M_Codo - Genérico:Estándar (236)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Estándar; ICAT_04-EstatusObra: Nueva construcción
Name (M_Codo - Genérico:Estándar:...) | In | ICAT-Volum (m3) | Group
684900 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 1
688142 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 3
689863 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 3
689873 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 3
689922 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 3
689974 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 3
689982 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 3
689984 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 3
690215 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 1
690223 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 1
690225 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 1
695318 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.000994506 | SAN_Fecal Aeri 1
695591 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.000989319 | SAN_Fecal Aeri 1
695607 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.000607747 | SAN_Fecal Aeri 1
695836 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.000988174 | SAN_Fecal Enterrat 1
695848 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.000988174 | SAN_Fecal Enterrat 1
696014 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.000497567 | SAN_Fecal Enterrat 1
696027 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.000497567 | SAN_Fecal Enterrat 1
696194 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0000563586 | SAN_Fecal Enterrat 1
696431 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000563586 | SAN_Fecal Aeri 1
696627 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000564513 | SAN_Fecal Aeri 1
696737 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0000563586 | SAN_Fecal Enterrat 1
697025 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0000264673 | SAN_Fecal Enterrat 1
697127 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.000944419 | SAN_Fecal Enterrat 1
697136 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.000938407 | SAN_Fecal Enterrat 1
697360 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.000535157 | SAN_Fecal Enterrat 1
775873 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 1
775968 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 2
776764 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 2
776766 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 1
776768 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 3
776793 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 2; AFIP 3
776901 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 1
