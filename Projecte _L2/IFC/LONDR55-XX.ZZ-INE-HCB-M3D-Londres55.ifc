Properties of the parts of a building model (IFC2X3), part 7 of 9

# IfcFlowFitting: M_Transición rectangular - Ángulo:60 grados (151)
Name (M_Transición rectangular - Ángulo:60 grados:...) | In | ICAT-Superficie (m2) | ICAT-Volum (m3) | Group
512638 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0279964 | 0.00122687 | AI 22
512940 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0306541 | 0.00163679 | AI 22
516745 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0654006 | 0.00541266 | AI 24
516827 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0654006 | 0.00541266 | AI 24
518699 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0373265 | 0.00189443 | Mecánica Aire de retorno 55
518700 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0342464 | 0.00169597 | Mecánica Aire de retorno 55
557653 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0461034 | 0.00292284 | Mecánica Aire de retorno 8
659542 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0401554 | 0.00259808 | AI 24
659595 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0401554 | 0.00259808 | AI 24
660028 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0511434 | 0.0034641 | AI 24
756505 | Nivel 1 | 0.0245365 | 0.00108253 | AI 19
764507 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0763157 | 0.00649519 | AP 1
767316 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0833253 | 0.00750555 | AI 25
767561 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0833253 | 0.00750555 | AE 1
769581 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.166315 | 0.0167432 | AI 24
769582 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.166315 | 0.0167432 | AI 24
769812 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.057594 | 0.0039783 | Mecánica Aire de retorno 55
769814 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0721362 | 0.00588176 | Mecánica Aire de retorno 55
769838 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0721362 | 0.00588176 | Mecánica Aire de retorno 55
771062 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.431451 | 0.0954116 | Mecánica Aire de retorno 32
771101 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.431451 | 0.0954116 | Mecánica Aire de retorno 44
771373 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.170667 | 0.0174648 | AI 24
771399 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.170673 | 0.0174648 | AI 24
771545 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.074641 | 0.0069282 | AI 24
789987 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0245365 | 0.00108253 | AI 22
796781 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.426692 | 0.0915822 | ASP 2
797988 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.159437 | 0.0233827 | ASP 3
803923 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.263564 | 0.0283094 | ASP 4
804174 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.426692 | 0.0915822 | ASP 4
806807 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.263564 | 0.0283094 | ASP 3
807513 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.348912 | 0.0638694 | ASP 3
808465 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.321014 | 0.047902 | ASP 3

# IfcFlowFitting: M_Transición redonda - Ángulo:60 grados, M_Transición redonda - Ángulo:60 grados:805170
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 60 grados; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 60 grados; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0100409 m2; ICAT-Volum: 0.000196279 m3
Group: AEWC 2; AE 3

# IfcFlowSegment: Conducto rectangular:Conducte_EI_EMPELT (30)
Classification: 50.30.40 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Conducte_EI_EMPELT; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR
Pset_FlowSegmentDuctSegment - sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Conducte_EI_EMPELT; ICAT_04-EstatusObra: Nueva construcción
Name (Conducto rectangular:Conducte_EI_EMPELT:...) | In | Pset_DuctSegmentTypeCommon, Length (m) = Pset_FlowSegmentDuctSegment, Length (m) | ICAT-Llarg (m) | ICAT-Superficie (m2) | Group
401349 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 3.66387 | 3.66387 | ASP 5
401488 | P04 - SECTORITZACIÓ I EVACUACIÓ | 2.35 | 2.35 | 2.585 | ASP 5
402277 | P04 - SECTORITZACIÓ I EVACUACIÓ | 2.93 | 2.93 | 2.93 | ASP 5
402555 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 2.6 | 2.6 | ASP 5
403748 | P04 - SECTORITZACIÓ I EVACUACIÓ | 1.23654 | 1.23654 | 2.47308 | ASP 5
405045 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 0.111094 | 0.122204 | ASP 5
405120 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.45 | 0.0185816 | 0.0371632 | ASP 5
405454 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 0.112432 | 0.123675 | ASP 5
405735 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 0.349952 | 0.384947 | ASP 5
406047 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00653792 | 0.00653792 | 0.0150372 | ASP 5
406131 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00653792 | 0.00653792 | 0.0150372 | ASP 5
408036 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.45 | 2.38858 | 4.77716 | ASP 5
408158 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.45 | 0.702158 | 1.40432 | ASP 5
408462 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.425 | 0.015 | 0.0495 | ASP 6
408482 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.775 | 0.139343 | 0.431964 | ASP 6
408719 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.635011 | 0.635011 | 1.27002 | ASP 5
408757 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.55 | 0.508611 | 1.01722 | ASP 5
424454 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.165 | 0.0150169 | 0.0357401 | AEPK 1
424726 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.165 | 0.0150169 | 0.0357401 | AEPK 1
424742 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.165 | 0.0150169 | 0.0357401 | AEPK 1
428555 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.8 | 0.516025 | 1.08365 | AEPK 1
428752 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.785 | 0.489903 | 1.53829 | AEPK 2
432059 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.35 | 0.0778178 | 0.13229 | Mecánica Aire Aportació PK EI 1
436219 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.165 | 0.0150169 | 0.0357401 | AEPK 1
436349 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.35 | 0.0141212 | 0.024006 | Mecánica Aire Aportació PK EI 1
436424 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.35 | 10.1742 | 17.2961 | Mecánica Aire Aportació PK EI 2
519509 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.425 | 0.00327432 | 0.0081858 | Mecánica Aire Aportació PK EI 2
519578 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.425 | 0.00327432 | 0.0081858 | Mecánica Aire Aportació PK EI 2
519589 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.425 | 0.00327432 | 0.0081858 | Mecánica Aire Aportació PK EI 2
519600 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.425 | 0.00327432 | 0.0081858 | Mecánica Aire Aportació PK EI 2

# IfcFlowSegment: Conducto rectangular:Conducte_EI_TE (5)
Classification: 50.30.40 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Conducte_EI_TE; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR
Pset_FlowSegmentDuctSegment - sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Conducte_EI_TE; ICAT_04-EstatusObra: Nueva construcción
Name (Conducto rectangular:Conducte_EI_TE:...) | In | Pset_DuctSegmentTypeCommon, Length (m) = Pset_FlowSegmentDuctSegment, Length (m) | ICAT-Llarg (m) | ICAT-Superficie (m2) | Group
397648 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 0.575 | 0.5175 | ASP 1
398200 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 1.44734 | 1.3026 | ASP 1
432466 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.35 | 0.194174 | 0.330095 | Mecánica Aire Aportació PK EI 2
432683 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.35 | 0.100167 | 0.170284 | Mecánica Aire Aportació PK EI 2
437736 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 11.3022 | 23.7346 | AEPK 1

# IfcFlowSegment: Conducto rectangular:Fibra de Vidre_TE (17)
In: P04 - SECTORITZACIÓ I EVACUACIÓ
Classification: 50.30.40 (Uniformat); Group: AI 1
Pset_DistributionFlowElementCommon - Reference: Fibra de Vidre_TE; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR
Pset_FlowSegmentDuctSegment - sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Fibra de Vidre_TE; ICAT_04-EstatusObra: Nueva construcción
Name (Conducto rectangular:Fibra de Vidre_TE:...) | Pset_DuctSegmentTypeCommon, Length (m) = Pset_FlowSegmentDuctSegment, Length (m) | ICAT-Llarg (m) | ICAT-Superficie (m2)
345767 | 0.15 | 2.7416 | 3.01576
350785 | 0.1 | 2.00105 | 1.60084
350796 | 0.175 | 3.32543 | 5.81951
351025 | 0.1 | 2.93 | 2.051
351038 | 0.1 | 2.5164 | 2.76804
351160 | 0.15 | 10.2261 | 12.2713
351287 | 0.1 | 2.975 | 2.38
351300 | 0.1 | 2.58524 | 2.32672
351352 | 0.1 | 3.35 | 2.345
351569 | 0.1 | 0.0926987 | 0.0648891
351770 | 0.15 | 5.494 | 4.9446
351832 | 0.1 | 7.05 | 4.935
352075 | 0.15 | 5.9584 | 5.36256
352131 | 0.15 | 1.26679 | 1.14012
352191 | 0.1 | 8.66 | 6.928
352372 | 0.1 | 5.6 | 4.48
355366 | 0.175 | 0.02 | 0.035

# IfcFlowSegment: Conducto rectangular:Xapa d'Acer_EMPELT (349)
Classification: 50.30.40 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Xapa d'Acer_EMPELT; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR
Pset_FlowSegmentDuctSegment - sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Xapa d'Acer_EMPELT; ICAT_04-EstatusObra: Nueva construcción
Name (Conducto rectangular:Xapa d'Acer_EMPELT:...) | In | Pset_DuctSegmentTypeCommon, Length (m) = Pset_FlowSegmentDuctSegment, Length (m) | ICAT-Llarg (m) | ICAT-Superficie (m2) | Group
362116 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.625 | 0.128557 | 0.244257 | ASP 1
382162 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.807583 | 0.807583 | 1.9382 | ASP 2
383258 | P04 - SECTORITZACIÓ I EVACUACIÓ | 2.96 | 2.96 | 2.96 | ASP 1
395321 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.625 | 0.0986649 | 0.187463 | ASP 2
395684 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0231924 | 0.0231924 | 0.0556617 | ASP 2
395763 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.804883 | 0.804883 | 1.93172 | ASP 2
395857 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.128974 | 0.128974 | 0.24505 | ASP 2
396562 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.426923 | 0.426923 | 1.02461 | ASP 1
397059 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.75 | 0.648083 | 1.5554 | ASP 1
397074 | P04 - SECTORITZACIÓ I EVACUACIÓ | 7.59912 | 7.59912 | 18.2379 | ASP 1
397443 | PS2 - SECTORITZACIÓ I EVACUACIÓ | 0.00941441 | 0.00941441 | 0.0178874 | ASP 1
397731 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 1.08434 | 0.975904 | ASP 1
398051 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.0901749 | 0.0901749 | 0.117227 | ASP 1
398428 | PS2 - SECTORITZACIÓ I EVACUACIÓ | 0.00577622 | 0.00577622 | 0.00750909 | ASP 1
400099 | P04 - SECTORITZACIÓ I EVACUACIÓ | 1.42318 | 1.42318 | 2.41941 | Mecánica Aire Aportació PK 1
400186 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.5 | 0.185547 | 0.31543 | Mecánica Aire Aportació PK 1
400599 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.5 | 0.227038 | 0.385965 | Mecánica Aire Aportació PK 1
401576 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 1.29 | 1.29 | ASP 5
401700 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.191538 | 0.191538 | 0.30263 | ASP 5
402736 | PS2 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 1.25 | 1.25 | ASP 5
402872 | PS2 - SECTORITZACIÓ I EVACUACIÓ | 0.00653792 | 0.00653792 | 0.0103299 | ASP 5
404071 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.578489 | 0.578489 | 0.983431 | Mecánica Aire Aportació PK 1
404186 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.35 | 0.229536 | 0.390211 | Mecánica Aire Aportació PK 1
404269 | P04 - SECTORITZACIÓ I EVACUACIÓ | 1.45 | 1.45 | 2.465 | Mecánica Aire Aportació PK 1
404670 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.5 | 0.220798 | 0.375356 | Mecánica Aire Aportació PK 1
404783 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.425 | 0.0804172 | 0.201043 | Mecánica Aire Aportació PK 1
407844 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.35 | 3.02 | 5.134 | Mecánica Aire Aportació PK 1
428468 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.785 | 0.02 | 0.0628 | AEPK 1
428570 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 0.0569915 | 0.119682 | AEPK 1
432163 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.635 | 0.0770172 | 0.195624 | Mecánica Aire Aportació PK EI 1
432551 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.635 | 0.0170172 | 0.0432236 | Mecánica Aire Aportació PK EI 2
434270 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.785 | 0.577609 | 1.81369 | AEPK 3
436542 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.35 | 9.47394 | 16.1057 | Mecánica Aire Aportació PK 1
438774 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 3.1667 | 1.90002 | AI 24
438956 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.7934 | 1.07604 | AI 24
439118 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 5.44 | 4.896 | AI 24
439188 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 0.682332 | 0.682332 | AI 24
439356 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 5.44 | 4.896 | AI 24
439757 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.5982 | 0.958918 | AI 24
439768 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 4.56927 | 4.56927 | AI 24
440228 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.76 | 0.456 | AI 24
443499 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 1.34 | 1.072 | Mecánica Aire de retorno 55
443618 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 1.415 | 1.132 | Mecánica Aire de retorno 55
443753 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.0233 | 0.613981 | Mecánica Aire de retorno 55
452034 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.41 | 0.246 | AI 22
452149 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.31 | 0.786 | AI 22
452442 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.41 | 0.246 | AI 22
452580 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 2.44325 | 1.46595 | AI 22
452628 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.19657 | 0.717945 | AI 22
452659 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.66133 | 0.996796 | AI 22
453630 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 7.137 | 9.56358 | AI 22
453746 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 2.62 | 1.834 | AI 22
453935 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 3.56 | 2.6344 | Mecánica Aire de retorno 5
454152 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 3.48241 | 3.62171 | Mecánica Aire de retorno 1
454380 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.88 | 0.752 | Mecánica Aire de retorno 3
455348 | Nivel 1 | 0.1 | 3.2433 | 1.94598 | AI 19
455490 | Nivel 1 | 0.15 | 4.55011 | 4.0951 | AI 19
456298 | Nivel 1 | 0.15 | 8.1 | 6.48 | AI 19
457604 | Nivel 1 | 0.1 | 2.325 | 1.395 | AI 19
458786 | Nivel 1 | 0.1 | 2.18894 | 0.875575 | Mecánica Aire de retorno 20
458918 | Nivel 1 | 0.1 | 0.508024 | 0.203209 | Mecánica Aire de retorno 20
458975 | Nivel 1 | 0.1 | 0.626835 | 0.250734 | Mecánica Aire de retorno 9
459418 | Nivel 1 | 0.1 | 2.07307 | 0.829229 | Mecánica Aire de retorno 9
459506 | Nivel 1 | 0.1 | 0.6 | 0.24 | Mecánica Aire de retorno 34
459596 | Nivel 1 | 0.1 | 1.86476 | 0.745902 | Mecánica Aire de retorno 34
459626 | Nivel 1 | 0.1 | 0.6 | 0.24 | Mecánica Aire de retorno 36
459627 | Nivel 1 | 0.1 | 1.86476 | 0.745902 | Mecánica Aire de retorno 36
459635 | Nivel 1 | 0.1 | 0.66 | 0.264 | Mecánica Aire de retorno 35
459636 | Nivel 1 | 0.1 | 1.86476 | 0.745902 | Mecánica Aire de retorno 35
459674 | Nivel 1 | 0.1 | 0.64 | 0.256 | Mecánica Aire de retorno 38
459675 | Nivel 1 | 0.1 | 1.86476 | 0.745902 | Mecánica Aire de retorno 38
459677 | Nivel 1 | 0.1 | 0.76 | 0.304 | Mecánica Aire de retorno 37
459678 | Nivel 1 | 0.1 | 1.86476 | 0.745902 | Mecánica Aire de retorno 37
459735 | Nivel 1 | 0.1 | 0.766835 | 0.306734 | Mecánica Aire de retorno 40
459736 | Nivel 1 | 0.1 | 1.86476 | 0.745902 | Mecánica Aire de retorno 40
459738 | Nivel 1 | 0.1 | 0.78 | 0.312 | Mecánica Aire de retorno 39
459739 | Nivel 1 | 0.1 | 1.86476 | 0.745902 | Mecánica Aire de retorno 39
459873 | Nivel 1 | 0.1 | 2.62 | 1.048 | Mecánica Aire de retorno 41
460017 | Nivel 1 | 0.1 | 2 | 0.8 | Mecánica Aire de retorno 61
460125 | Nivel 1 | 0.1 | 3 | 1.2 | Mecánica Aire de retorno 62
460528 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 4.06783 | 3.66104 | AI 21
461390 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.2117 | 0.727019 | AI 21
462993 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.81438 | 0.725754 | Mecánica Aire de retorno 19
463132 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 3.81574 | 2.67102 | Mecánica Aire de retorno 7
463217 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.596972 | 0.41788 | Mecánica Aire de retorno 7
463273 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.66 | 0.664 | Mecánica Aire de retorno 10
463437 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.71 | 0.284 | Mecánica Aire de retorno 10
463553 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.66 | 0.664 | Mecánica Aire de retorno 11
463554 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.71 | 0.284 | Mecánica Aire de retorno 11
463576 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.66 | 0.664 | Mecánica Aire de retorno 12
463577 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.71 | 0.284 | Mecánica Aire de retorno 12
463690 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.61 | 0.427 | Mecánica Aire de retorno 8
463807 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.0952 | 0.876159 | Mecánica Aire de retorno 8
464734 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.95 | 0.57 | Mecánica Aire de retorno 8
465203 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.08 | 0.648 | Mecánica Aire de retorno 8
465582 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 3.13577 | 1.88146 | Mecánica Aire de retorno 8
465701 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.68 | 0.408 | Mecánica Aire de retorno 8
466977 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.755 | 0.5285 | AI 21
467286 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.175 | 0.883877 | 1.54679 | AI 23
467663 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.18 | 0.708 | AI 23
467717 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.18 | 0.708 | AI 23
467837 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.2117 | 0.727019 | AI 23
467902 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.2 | 0.72 | AI 23
468130 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 5.18 | 3.626 | AI 23
468522 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.98 | 0.792 | AI 23
468649 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 2.37 | 0.948 | Mecánica Aire de retorno 13
468888 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 2.12369 | 0.849475 | Mecánica Aire de retorno 33
468945 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 2.80138 | 1.12055 | Mecánica Aire de retorno 33
468997 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 2.51213 | 1.00485 | Mecánica Aire de retorno 14
469031 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.60777 | 0.643106 | Mecánica Aire de retorno 14
469432 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 2.64 | 1.056 | Mecánica Aire de retorno 31
469439 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 4.8 | 1.92 | Mecánica Aire de retorno 31
469625 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.22949 | 0.491796 | Mecánica Aire de retorno 16
469790 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.61144 | 0.966865 | Mecánica Aire de retorno 17
469900 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.92949 | 0.371796 | Mecánica Aire de retorno 17
470002 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.04731 | 0.733114 | Mecánica Aire de retorno 15
470028 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 2.44 | 1.708 | Mecánica Aire de retorno 15
470548 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.77 | 0.708 | Mecánica Aire de retorno 23
470668 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.77 | 0.708 | Mecánica Aire de retorno 42
470688 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 2.0186 | 0.80744 | Mecánica Aire de retorno 22
471540 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 13.0634 | 16.9824 | AI 18
471686 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.44 | 0.864 | AI 18
471992 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 6.3 | 6.93 | AI 18
472084 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 2.1 | 2.31 | AI 18
472180 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 3.84453 | 2.69117 | AI 18
472323 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 15 | 15 | AI 18
472383 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 4.49645 | 3.59716 | AI 18
472531 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.59 | 0.354 | Mecánica Aire de retorno 27
472532 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 4.72 | 2.832 | Mecánica Aire de retorno 27
472651 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.38 | 0.228 | Mecánica Aire de retorno 30
472652 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 3.11 | 1.866 | Mecánica Aire de retorno 30
472709 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 3.61441 | 2.16865 | Mecánica Aire de retorno 54
472789 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.358594 | 0.143438 | Mecánica Aire de retorno 53
472790 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.67859 | 0.671438 | Mecánica Aire de retorno 53
472935 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.52 | 0.208 | Mecánica Aire de retorno 29
472936 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.56 | 0.624 | Mecánica Aire de retorno 29
473370 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 4.34 | 2.604 | AI 23
473475 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.03 | 0.03 | 0.03 | AI 23
473910 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 3.29159 | 2.63327 | AI 23
474455 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.005 | AI 23
474759 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.01 | 0.01 | 0.01 | AI 23
474947 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.01 | 0.01 | 0.01 | AI 23
475055 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.01 | 0.01 | 0.01 | AI 23
475277 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.025 | 0.025 | 0.025 | AI 23
475303 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.005 | AI 23
475327 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.005 | AI 23
475572 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.005 | AI 23
476811 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0035 | Mecánica Aire de retorno 31
478117 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.0913803 | 0.0639662 | Mecánica Aire de retorno 31
478669 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0035 | Mecánica Aire de retorno 13
478854 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0035 | Mecánica Aire de retorno 33
479062 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.0847754 | 0.0593428 | Mecánica Aire de retorno 33
479261 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0035 | Mecánica Aire de retorno 14
479420 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.120652 | 0.0844565 | Mecánica Aire de retorno 14
479557 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0055 | Mecánica Aire de retorno 15
479750 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.146189 | 0.160808 | Mecánica Aire de retorno 15
480014 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0075 | 0.0075 | 0.0075 | AI 23
480209 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.0026205 | 0.00183435 | Mecánica Aire de retorno 16
480401 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00433932 | 0.00303752 | Mecánica Aire de retorno 17
480617 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00306916 | 0.00214841 | Mecánica Aire de retorno 17
480787 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.3975 | 0.2385 | Mecánica Aire de retorno 17
480938 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.105964 | 0.11656 | Mecánica Aire de retorno 17
483324 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00445393 | 0.00311775 | AI 23
484264 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.01 | 0.01 | 0.01 | AI 21
484527 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.01 | 0.01 | 0.01 | AI 21
484558 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.03 | 0.03 | 0.03 | AI 21
484775 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.005 | AI 21
484959 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.005 | AI 21
485225 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.01 | 0.01 | 0.01 | AI 21
485444 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.64 | 0.384 | AI 21
485534 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.015 | 0.015 | 0.015 | AI 21
485805 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.27133 | 0.50853 | AI 21
486115 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0075 | 0.0075 | 0.006 | AI 21
486344 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.01 | 0.01 | 0.01 | AI 21
489869 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.43739 | 1.00617 | AI 21
489880 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.76 | 1.232 | AI 21
490105 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 2.52617 | 1.5157 | AI 21
490256 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.87949 | 1.1277 | AI 21
490385 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.005 | AI 21
490557 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.015 | 0.015 | 0.015 | AI 21
490882 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.01 | 0.01 | 0.01 | AI 21
491032 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.287414 | 0.114966 | Mecánica Aire de retorno 19
491103 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0035 | Mecánica Aire de retorno 19
491296 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.0944652 | 0.0661256 | Mecánica Aire de retorno 19
491560 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.0928629 | 0.102149 | Mecánica Aire de retorno 7
491750 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0055 | Mecánica Aire de retorno 7
492228 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0055 | Mecánica Aire de retorno 8
492570 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.0171148 | 0.0119803 | Mecánica Aire de retorno 8
492744 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00255816 | 0.00179071 | Mecánica Aire de retorno 8
493010 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.01 | 0.01 | 0.007 | Mecánica Aire de retorno 8
493227 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00672546 | 0.007398 | Mecánica Aire de retorno 8
493582 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0035 | Mecánica Aire de retorno 12
493712 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0035 | Mecánica Aire de retorno 11
493816 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0035 | Mecánica Aire de retorno 10
493969 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.154244 | 0.107971 | Mecánica Aire de retorno 10
494009 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.154244 | 0.107971 | Mecánica Aire de retorno 11
494022 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.154244 | 0.107971 | Mecánica Aire de retorno 12
494033 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.100175 | 0.0701225 | Mecánica Aire de retorno 8
494373 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0035 | Mecánica Aire de retorno 8
497045 | Nivel 1 | 0.015 | 0.015 | 0.015 | AI 19
497072 | Nivel 1 | 0.01 | 0.01 | 0.01 | AI 19
497096 | Nivel 1 | 0.01 | 0.01 | 0.01 | AI 19
497283 | Nivel 1 | 0.015 | 0.015 | 0.015 | AI 19
497307 | Nivel 1 | 0.01 | 0.01 | 0.01 | AI 19
497328 | Nivel 1 | 0.01 | 0.01 | 0.01 | AI 19
498007 | Nivel 1 | 0.005 | 0.005 | 0.005 | AI 19
498155 | Nivel 1 | 0.005 | 0.005 | 0.005 | AI 19
498419 | Nivel 1 | 0.0075 | 0.0075 | 0.006 | AI 19
500538 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 20
500843 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 9
501108 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 34
501244 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 35
501429 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 36
501567 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 37
501631 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 38
501754 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 39
501816 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 40
501919 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 41
502312 | Nivel 1 | 0.125 | 0.097 | 0.0679 | Mecánica Aire de retorno 37
502494 | Nivel 1 | 0.125 | 0.097 | 0.0679 | Mecánica Aire de retorno 34
502589 | Nivel 1 | 0.125 | 0.097 | 0.0679 | Mecánica Aire de retorno 36
502615 | Nivel 1 | 0.125 | 0.097 | 0.0679 | Mecánica Aire de retorno 35
502633 | Nivel 1 | 0.125 | 0.097 | 0.0679 | Mecánica Aire de retorno 40
502651 | Nivel 1 | 0.125 | 0.097 | 0.0679 | Mecánica Aire de retorno 39
502674 | Nivel 1 | 0.125 | 0.097 | 0.0679 | Mecánica Aire de retorno 38
502898 | Nivel 1 | 0.125 | 0.125615 | 0.0879307 | Mecánica Aire de retorno 9
502984 | Nivel 1 | 0.125 | 0.142674 | 0.0998719 | Mecánica Aire de retorno 20
503280 | Nivel 1 | 0.125 | 0.105011 | 0.0735074 | Mecánica Aire de retorno 41
503512 | Nivel 1 | 0.1 | 3.34 | 1.336 | Mecánica Aire de retorno 63
503531 | Nivel 1 | 0.1 | 0.308606 | 0.123443 | Mecánica Aire de retorno 63
503547 | Nivel 1 | 0.1 | 1.22861 | 0.491443 | Mecánica Aire de retorno 63
503596 | Nivel 1 | 0.1 | 3.34 | 1.336 | Mecánica Aire de retorno 64
503598 | Nivel 1 | 0.1 | 0.308606 | 0.123443 | Mecánica Aire de retorno 64
503599 | Nivel 1 | 0.1 | 1.12861 | 0.451443 | Mecánica Aire de retorno 64
503650 | Nivel 1 | 0.125 | 0.0841807 | 0.0589265 | Mecánica Aire de retorno 64
503784 | Nivel 1 | 0.125 | 0.128277 | 0.0897938 | Mecánica Aire de retorno 63
504004 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 64
504052 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 63
504144 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 62
504309 | Nivel 1 | 0.125 | 0.178385 | 0.124869 | Mecánica Aire de retorno 62
504410 | Nivel 1 | 0.125 | 0.108385 | 0.0758695 | Mecánica Aire de retorno 61
504593 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 61
504657 | Nivel 1 | 0.125 | 0.114569 | 0.0801981 | Mecánica Aire de retorno 43
504801 | Nivel 1 | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 43
505216 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00977076 | 0.00977076 | 0.00977076 | AI 18
505242 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.01 | 0.01 | 0.01 | AI 18
505268 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.01 | 0.01 | 0.01 | AI 18
505291 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.01 | 0.01 | 0.01 | AI 18
505530 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.005 | AI 18
505554 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00465803 | 0.00465803 | 0.00465803 | AI 18
505592 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.005 | AI 18
505613 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.015 | 0.015 | 0.015 | AI 18
505964 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0141987 | 0.0141987 | 0.011359 | AI 18
506179 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.005 | AI 18
506203 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.005 | AI 18
506441 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.005 | AI 18
506626 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.003495 | 0.0024465 | AI 18
506944 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00268491 | 0.00187944 | AI 18
507255 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 53
507408 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0125 | 0.0125 | 0.00875 | Mecánica Aire de retorno 29
507566 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.118044 | 0.0826307 | Mecánica Aire de retorno 29
507595 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.118044 | 0.0826307 | Mecánica Aire de retorno 53
507821 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.100024 | 0.0700167 | Mecánica Aire de retorno 30
507958 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.0900239 | 0.0630167 | Mecánica Aire de retorno 27
508399 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 27
508622 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0075 | 0.0075 | 0.00525 | Mecánica Aire de retorno 30
509010 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0075 | 0.0075 | 0.00825 | Mecánica Aire de retorno 54
509157 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.105653 | 0.116218 | Mecánica Aire de retorno 54
509460 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.015 | 0.015 | 0.012 | AI 22
509486 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.015 | 0.015 | 0.012 | AI 22
509507 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.015 | 0.015 | 0.012 | AI 22
509685 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0125 | 0.0125 | 0.0125 | AI 22
509827 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0125 | 0.0125 | 0.0125 | AI 22
510136 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0083259 | 0.0083259 | 0.0083259 | AI 22
510627 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0375 | 0.0375 | 0.0375 | AI 22
510685 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0375 | 0.0375 | 0.0375 | AI 22
510711 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0375 | 0.0375 | 0.0375 | AI 22
510793 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0375 | 0.0375 | 0.0375 | AI 22
511805 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0375 | 0.0375 | 0.0375 | AI 22
511810 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.31 | 0.786 | AI 22
511815 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0375 | 0.0375 | 0.0375 | AI 22
511816 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.41 | 0.246 | AI 22
512203 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0375 | 0.0375 | 0.0375 | AI 22
512683 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.74 | 0.518 | AI 22
512811 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0125 | 0.0125 | 0.0125 | AI 22
512956 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0375 | 0.0375 | 0.0375 | AI 22
513059 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0125 | 0.0125 | 0.0125 | AI 22
513083 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0375 | 0.0375 | 0.0375 | AI 22
514041 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.057 | 0.057 | 0.0627 | Mecánica Aire de retorno 4
514043 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.44 | 0.3696 | Mecánica Aire de retorno 4
514551 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.092 | 0.092 | 0.0644 | Mecánica Aire de retorno 3
514758 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.057 | 0.057 | 0.0627 | Mecánica Aire de retorno 4
514892 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.057 | 0.057 | 0.0627 | Mecánica Aire de retorno 28
514893 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.44 | 0.3696 | Mecánica Aire de retorno 28
514898 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.057 | 0.057 | 0.0627 | Mecánica Aire de retorno 28
515049 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.057 | 0.057 | 0.0627 | Mecánica Aire de retorno 5
515235 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.995131 | 0.736397 | Mecánica Aire de retorno 5
515345 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.057 | 0.057 | 0.0627 | Mecánica Aire de retorno 5
515504 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.057 | 0.057 | 0.0627 | Mecánica Aire de retorno 1
515626 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.489911 | 0.509507 | Mecánica Aire de retorno 1
515672 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.057 | 0.057 | 0.0627 | Mecánica Aire de retorno 1
516047 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.092 | 0.092 | 0.0644 | Mecánica Aire de retorno 3
516569 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0170379 | 0.0170379 | 0.0170379 | AI 24
516595 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0170379 | 0.0170379 | 0.0170379 | AI 24
516616 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0170379 | 0.0170379 | 0.0170379 | AI 24
516866 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00703792 | 0.00703792 | 0.00703792 | AI 24
516890 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00703792 | 0.00703792 | 0.00703792 | AI 24
516916 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00703792 | 0.00703792 | 0.00703792 | AI 24
517149 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00700392 | 0.00700392 | 0.00700392 | AI 24
517171 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00700392 | 0.00700392 | 0.00700392 | AI 24
517197 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00700392 | 0.00700392 | 0.00700392 | AI 24
517552 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0295379 | 0.0295379 | 0.0295379 | AI 24
517784 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0295379 | 0.0295379 | 0.0295379 | AI 24
518060 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0295379 | 0.0295379 | 0.0295379 | AI 24
518205 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.225 | 0.00739943 | 0.00813937 | Mecánica Aire de retorno 55
518430 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0145379 | 0.0145379 | 0.0101765 | Mecánica Aire de retorno 55
518768 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00453792 | 0.00453792 | 0.00317654 | Mecánica Aire de retorno 55
518830 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00453792 | 0.00453792 | 0.00317654 | Mecánica Aire de retorno 55
659852 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00828792 | 0.00828792 | 0.00828792 | AI 24
757230 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0035 | Mecánica Aire de retorno 23
757321 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0035 | Mecánica Aire de retorno 42
757532 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0035 | Mecánica Aire de retorno 22
757706 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | 0.005 | 0.0035 | Mecánica Aire de retorno 21
759212 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.625 | 0.00355654 | 0.00675742 | ASP 1
759404 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.625 | 0.101586 | 0.193013 | ASP 2
759482 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.625 | 0.101586 | 0.193013 | ASP 2
759553 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.625 | 0.101586 | 0.193013 | ASP 2
759626 | Nivel 1 | 0.625 | 0.101586 | 0.193013 | ASP 2
759691 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.625 | 0.101586 | 0.193013 | ASP 2
763986 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 1.19617 | 1.4354 | AE 2
764426 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 1.12588 | 1.12588 | AP 1
764550 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.325 | 0.0414206 | 0.0538468 | AE 2
764733 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.225 | 0.330162 | 0.363178 | AP 1
765021 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 0.275131 | 0.275131 | AP 1
765075 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.185706 | 0.185706 | AP 1
765182 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.4 | 0.183397 | 0.220077 | AI 25
765192 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.4 | 1.7 | 2.04 | AI 25
765324 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.325 | 0.0105246 | 0.0242066 | AI 25
767792 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.4 | 0.45 | 0.54 | Mecánica Aire de retorno 45
767929 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.825 | 0.00990381 | 0.0227788 | Mecánica Aire de retorno 45
781251 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 2.9383 | 1.76298 | Mecánica Aire de retorno 8
789895 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.346575 | 0.207945 | AI 22
789941 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.713899 | 0.42834 | AI 22
789995 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 0.0461495 | 0.0276897 | AI 22
790092 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 0.0461495 | 0.0276897 | AI 22
796721 | P04 - SECTORITZACIÓ I EVACUACIÓ | 18.2954 | 18.2954 | 43.9089 | ASP 2
798386 | P04 - SECTORITZACIÓ I EVACUACIÓ | 23.9218 | 23.9218 | 23.9218 | ASP 1
798457 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.75 | 0.409495 | 0.982787 | ASP 1
798471 | P04 - SECTORITZACIÓ I EVACUACIÓ | 17.2223 | 17.2223 | 41.3335 | ASP 1

# IfcFlowSegment: Conducto rectangular:Xapa d'Acer_TE (256)
Classification: 50.30.40 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Xapa d'Acer_TE; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR
Pset_FlowSegmentDuctSegment - sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Xapa d'Acer_TE; ICAT_04-EstatusObra: Nueva construcción
Name (Conducto rectangular:Xapa d'Acer_TE:...) | In | Pset_DuctSegmentTypeCommon, Length (m) = Pset_FlowSegmentDuctSegment, Length (m) | ICAT-Llarg (m) | ICAT-Superficie (m2) | Group
402051 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.0501707 | 0.0551878 | ASP 5
402386 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.190962 | 0.210058 | ASP 5
438369 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.3975 | 0.67575 | AI 24
438815 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 1.81349 | 1.81349 | AI 24
438825 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.752089 | 1.27855 | AI 24
438969 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 2.28611 | 1.82889 | AI 24
439131 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.621881 | 0.995009 | AI 24
439416 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 2.13 | 3.408 | AI 24
440051 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.1 | 0.17 | AI 24
440205 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.61265 | 0.36759 | AI 24
443706 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 2.20656 | 1.9859 | Mecánica Aire de retorno 55
443771 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 0.101313 | 0.0810504 | Mecánica Aire de retorno 55
443800 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 1.04561 | 0.836485 | Mecánica Aire de retorno 55
443917 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 0.391034 | 0.35193 | Mecánica Aire de retorno 55
444082 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 0.106953 | 0.0855626 | Mecánica Aire de retorno 55
444228 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 2.43276 | 1.94621 | Mecánica Aire de retorno 55
450942 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 3.6606 | 5.63733 | AI 22
451290 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 2.26 | 5.2884 | AI 22
451456 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.41627 | 0.391294 | AI 22
451943 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.331213 | 0.443825 | AI 22
451969 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.31 | 0.786 | AI 22
452390 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 1.95 | 2.613 | AI 22
452441 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 2.1 | 2.814 | AI 22
452511 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.10437 | 0.773058 | AI 22
452675 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.45768 | 1.16614 | AI 22
453739 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 2.73319 | 1.91323 | AI 22
454269 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.176389 | 0.0705557 | Mecánica Aire de retorno 3
454525 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.04 | 0.0936 | AI 22
454664 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 1.035 | 0.8694 | Mecánica Aire de retorno 4
454909 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 1.64237 | 3.84314 | Mecánica Aire de retorno 6
455060 | Nivel 1 | 0.175 | 0.497289 | 0.870256 | AI 19
455307 | Nivel 1 | 0.175 | 0.584595 | 1.02304 | AI 19
455322 | Nivel 1 | 0.15 | 0.951919 | 1.52307 | AI 19
455358 | Nivel 1 | 0.175 | 0.494933 | 0.866133 | AI 19
455477 | Nivel 1 | 0.1 | 2.33198 | 0.932791 | AI 19
456157 | Nivel 1 | 0.15 | 0.129868 | 0.207788 | AI 19
456563 | Nivel 1 | 0.15 | 0.712252 | 1.1396 | AI 19
456602 | Nivel 1 | 0.15 | 0.075 | 0.0975 | AI 19
456615 | Nivel 1 | 0.15 | 0.29 | 0.377 | AI 19
456623 | Nivel 1 | 0.15 | 0.1 | 0.13 | AI 19
456898 | Nivel 1 | 0.15 | 0.0957397 | 0.0574438 | AI 19
457099 | Nivel 1 | 0.15 | 2.0382 | 1.22292 | AI 19
457221 | Nivel 1 | 0.1 | 0.956904 | 0.382762 | AI 19
457234 | Nivel 1 | 0.15 | 0.231905 | 0.278286 | AI 19
457361 | Nivel 1 | 0.15 | 0.376791 | 0.376791 | AI 19
457369 | Nivel 1 | 0.15 | 3.56913 | 4.28296 | AI 19
457410 | Nivel 1 | 0.15 | 1.3 | 0.78 | AI 19
457425 | Nivel 1 | 0.15 | 0.442403 | 0.442403 | AI 19
457540 | Nivel 1 | 0.15 | 0.207501 | 0.1245 | AI 19
457610 | Nivel 1 | 0.15 | 0.53541 | 0.53541 | AI 19
457641 | Nivel 1 | 0.15 | 0.187626 | 0.112576 | AI 19
457775 | Nivel 1 | 0.15 | 0.161617 | 0.161617 | AI 19
457886 | Nivel 1 | 0.15 | 0.0587161 | 0.0352296 | AI 19
457894 | Nivel 1 | 0.15 | 3.00959 | 3.00959 | AI 19
458008 | Nivel 1 | 0.15 | 0.210728 | 0.126437 | AI 19
458021 | Nivel 1 | 0.15 | 0.275138 | 0.330166 | AI 19
458217 | Nivel 1 | 0.1 | 1.75974 | 0.703896 | Mecánica Aire de retorno 43
458553 | Nivel 1 | 0.1 | 0.305 | 0.122 | Mecánica Aire de retorno 43
458574 | Nivel 1 | 0.1 | 0.104688 | 0.041875 | Mecánica Aire de retorno 43
459407 | Nivel 1 | 0.1 | 0.0552626 | 0.0221051 | Mecánica Aire de retorno 9
459942 | Nivel 1 | 0.1 | 0.28 | 0.112 | Mecánica Aire de retorno 41
460218 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.175 | 0.0453974 | 0.0794455 | AI 21
460398 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 2.72057 | 1.63234 | AI 21
460409 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.175 | 1.48841 | 2.60471 | AI 21
460515 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.675 | 0.67 | AI 21
461162 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.175 | 0.575456 | 1.00705 | AI 21
461179 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.175 | 0.9234 | 1.61595 | AI 21
461205 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 2.53261 | 1.51956 | AI 21
461351 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.18 | 0.708 | AI 21
461400 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 3.65146 | 2.55602 | AI 21
461463 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.48314 | 2.22471 | AI 21
461705 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.459965 | 0.689947 | AI 21
461720 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.353372 | 0.530058 | AI 21
461838 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.04 | 0.06 | AI 21
462125 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 3.93349 | 2.3601 | AI 21
462135 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.71514 | 1.2006 | AI 21
462176 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.710192 | 0.426115 | AI 21
462229 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.532166 | 0.691815 | AI 21
462313 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.337868 | 0.439228 | AI 21
462324 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.350458 | 0.455595 | AI 21
462458 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.09912 | 1.42886 | AI 21
463796 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.16 | 0.112 | Mecánica Aire de retorno 8
463864 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.98719 | 1.58975 | Mecánica Aire de retorno 8
463940 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.334 | 0.9338 | Mecánica Aire de retorno 8
464119 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 3.54727 | 4.25672 | Mecánica Aire de retorno 8
464287 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.40451 | 2.10676 | Mecánica Aire de retorno 8
464356 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.16138 | 1.39365 | Mecánica Aire de retorno 8
464505 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.342843 | 0.514264 | Mecánica Aire de retorno 8
464680 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.581404 | 0.872105 | Mecánica Aire de retorno 8
464744 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.19485 | 0.23382 | Mecánica Aire de retorno 8
465056 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.34 | 1.206 | Mecánica Aire de retorno 8
465343 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.00655534 | 0.00589981 | Mecánica Aire de retorno 8
465709 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.194643 | 0.291965 | Mecánica Aire de retorno 8
465789 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.30101 | 1.95151 | Mecánica Aire de retorno 8
465845 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.409048 | 0.613572 | Mecánica Aire de retorno 8
466044 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.0690974 | 0.103646 | Mecánica Aire de retorno 8
466051 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.45688 | 2.18533 | Mecánica Aire de retorno 8
466274 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.160532 | 0.0642129 | AI 21
466287 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.609162 | 0.913744 | AI 21
466386 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.169981 | 0.0679923 | AI 21
466570 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.15 | 0.225 | AI 21
466825 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.170981 | 0.0683923 | AI 21
466833 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 3.41767 | 5.1265 | AI 21
466985 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.607323 | 0.910985 | AI 21
467021 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.175 | 0.340528 | 0.595924 | AI 23
467078 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.175 | 1.15 | 2.0125 | AI 23
467165 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.22625 | 0.113125 | AI 23
467189 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.63 | 0.315 | AI 23
467200 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 3.10616 | 1.55308 | AI 23
467203 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.18 | 0.09 | AI 23
467243 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.175 | 0.158213 | 0.276872 | AI 23
467331 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 2.56519 | 3.33475 | AI 23
467374 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.06568 | 0.745973 | AI 23
467453 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.736699 | 0.442019 | AI 23
467463 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 3.19101 | 4.14831 | AI 23
467550 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.30684 | 0.784102 | AI 23
467847 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 3.04076 | 2.12853 | AI 23
467916 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 6.69952 | 8.70937 | AI 23
468240 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.495145 | 0.297087 | AI 23
468368 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.02 | 0.408 | AI 23
468474 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.365 | 0.146 | AI 23
468587 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.245 | 0.147 | AI 23
468609 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.295 | 0.177 | AI 23
468615 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 2.47486 | 1.48491 | AI 23
468820 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.19 | 0.076 | Mecánica Aire de retorno 13
469592 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 4.3884 | 1.75536 | Mecánica Aire de retorno 16
469616 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.035397 | 0.0141588 | Mecánica Aire de retorno 16
469754 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 4.26231 | 2.55738 | Mecánica Aire de retorno 17
469897 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.328062 | 0.196837 | Mecánica Aire de retorno 17
469898 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.035397 | 0.0141588 | Mecánica Aire de retorno 17
469945 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.1 | 0.06 | Mecánica Aire de retorno 17
469956 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 4.16509 | 1.66604 | Mecánica Aire de retorno 17
470468 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 2.63896 | 1.84727 | Mecánica Aire de retorno 21
470504 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.757678 | 0.530374 | Mecánica Aire de retorno 21
470607 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.36 | 0.144 | Mecánica Aire de retorno 23
470669 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.36 | 0.144 | Mecánica Aire de retorno 42
470689 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.367396 | 0.146958 | Mecánica Aire de retorno 22
470807 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.175 | 2.25497 | 5.07369 | AI 18
470808 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.865379 | 1.29807 | Mecánica Aire de retorno 25
470939 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.4433 | 0.865981 | AI 18
471245 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.175 | 0.214605 | 0.482862 | AI 18
471296 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 2.47835 | 3.22185 | AI 18
471432 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.175 | 0.27247 | 0.613058 | AI 18
471528 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.775 | 1.2425 | AI 18
471617 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.55311 | 0.931865 | AI 18
471717 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 2.9 | 2.03 | AI 18
471860 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.676891 | 0.406135 | AI 18
471925 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.195048 | 0.117029 | AI 18
472502 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.9937 | 0.79496 | AI 18
472515 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.96659 | 1.57327 | AI 18
473155 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.0377083 | 0.022625 | AI 23
473339 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.833517 | 0.50011 | AI 23
473838 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 3.65229 | 2.19138 | AI 23
474132 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.01 | 0.017 | AI 23
474218 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.0615934 | 0.0492747 | AI 23
474412 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.447956 | 0.358365 | AI 23
478458 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00415069 | 0.00290548 | Mecánica Aire de retorno 13
481105 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00771079 | 0.00539755 | Mecánica Aire de retorno 16
482347 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00379226 | 0.00265458 | AI 23
482572 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00504226 | 0.00352958 | AI 23
482780 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00334353 | 0.00234047 | AI 23
483070 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00839597 | 0.00587718 | AI 23
483114 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00839597 | 0.00587718 | AI 23
485681 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.43137 | 0.572549 | AI 21
485692 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.175 | 1.48965 | 2.60689 | AI 21
485791 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.224508 | 0.089803 | AI 21
486855 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.291278 | 0.26215 | Mecánica Aire de retorno 8
486890 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.130513 | 0.117462 | Mecánica Aire de retorno 8
486976 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.0700967 | 0.063087 | Mecánica Aire de retorno 8
490112 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.281092 | 0.168655 | AI 21
490126 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 3.71394 | 3.34255 | AI 21
490263 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.120016 | 0.0720097 | AI 21
490298 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.74357 | 1.56921 | AI 21
491018 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.0342988 | 0.0137195 | Mecánica Aire de retorno 19
494725 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.825 | 0.14 | 0.322 | Mecánica Aire de retorno 18
495154 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.0134681 | 0.00942764 | AI 21
495237 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00401959 | 0.00281371 | AI 21
495252 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00301959 | 0.00211371 | AI 21
496268 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.125 | 0.00581808 | 0.00407265 | AI 21
497772 | Nivel 1 | 0.1 | 2.325 | 1.395 | AI 19
499067 | Nivel 1 | 0.15 | 0.210728 | 0.126437 | AI 19
499172 | Nivel 1 | 0.15 | 0.210728 | 0.126437 | AI 19
499182 | Nivel 1 | 0.15 | 0.210728 | 0.126437 | AI 19
499192 | Nivel 1 | 0.15 | 0.210728 | 0.126437 | AI 19
499210 | Nivel 1 | 0.15 | 0.360728 | 0.216437 | AI 19
499220 | Nivel 1 | 0.15 | 0.360728 | 0.216437 | AI 19
499230 | Nivel 1 | 0.15 | 0.011993 | 0.0071958 | AI 19
499242 | Nivel 1 | 0.15 | 0.149037 | 0.0894221 | AI 19
499311 | Nivel 1 | 0.15 | 0.72 | 0.432 | AI 19
499341 | Nivel 1 | 0.15 | 2.57168 | 1.54301 | AI 19
499374 | Nivel 1 | 0.15 | 0.8 | 0.96 | AI 19
499405 | Nivel 1 | 0.15 | 4.4 | 5.28 | AI 19
499429 | Nivel 1 | 0.15 | 0.7 | 0.84 | AI 19
499912 | Nivel 1 | 0.15 | 2.2926 | 1.37556 | AI 19
499943 | Nivel 1 | 0.15 | 0.136134 | 0.0816804 | AI 19
500189 | Nivel 1 | 0.1 | 1.7266 | 0.690641 | AI 19
500209 | Nivel 1 | 0.1 | 0.26641 | 0.106564 | AI 19
500224 | Nivel 1 | 0.1 | 0.289529 | 0.115812 | AI 19
506942 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.197858 | 0.118715 | AI 18
510188 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.593 | 0.91322 | AI 22
512542 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.71 | 0.568 | AI 22
513939 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 1.32324 | 1.11152 | Mecánica Aire de retorno 4
514885 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.126759 | 0.106478 | Mecánica Aire de retorno 28
514886 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.735 | 0.6174 | Mecánica Aire de retorno 28
514891 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 1.32324 | 1.11152 | Mecánica Aire de retorno 28
515246 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.8 | 0.592 | Mecánica Aire de retorno 5
515969 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 0.435 | 0.174 | Mecánica Aire de retorno 3
516154 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.1 | 1.19361 | 0.477444 | Mecánica Aire de retorno 3
556129 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.0262004 | 0.0193883 | Mecánica Aire de retorno 5
557616 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.005 | 0.0045 | Mecánica Aire de retorno 8
659312 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 0.822622 | 0.74036 | Mecánica Aire de retorno 55
659325 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 0.138168 | 0.124351 | Mecánica Aire de retorno 55
659336 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 0.00778655 | 0.00700789 | Mecánica Aire de retorno 55
660023 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.25 | 0.00510383 | 0.00510383 | AI 24
680783 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.191213 | 0.256225 | AI 22
680813 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.0771077 | 0.0724812 | AI 22
680962 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.701889 | 0.940531 | AI 22
681024 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.17 | 0.542622 | 0.510065 | AI 22
763977 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.140466 | 0.168559 | AE 2
764416 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 0.0337252 | 0.0337252 | AP 1
767175 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.4 | 0.15 | 0.18 | Mecánica Aire de retorno 45
767515 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.4 | 0.273397 | 0.328077 | AE 1
768337 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.2 | 0.220948 | 0.198853 | Mecánica Aire de retorno 55
769148 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.624164 | 0.998662 | AI 24
770293 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.825 | 0.1 | 0.23 | Mecánica Aire de retorno 44
770769 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.825 | 0.129591 | 0.298058 | Mecánica Aire de retorno 32
771335 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.101248 | 0.172121 | AI 24
771539 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.37 | 0.629 | AI 24
780555 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.0621648 | 0.0745978 | Mecánica Aire de retorno 8
780627 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.45 | 0.0979757 | 0.117571 | Mecánica Aire de retorno 8
780718 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.440021 | 0.528025 | Mecánica Aire de retorno 8
780723 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.45 | 0.0925744 | 0.111089 | Mecánica Aire de retorno 8
782378 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.776808 | 0.699127 | AI 21
785139 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.0746152 | 0.0671537 | AI 21
785154 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 0.208948 | 0.188053 | AI 21
785221 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.0468734 | 0.0421861 | AI 21
785234 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.15 | 1.76294 | 1.58665 | AI 21
797654 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.75 | 1.08596 | 2.60631 | ASP 3
797948 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.00801687 | 0.00801687 | ASP 3
797998 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 0.20759 | 0.20759 | ASP 1; ASP 3
798166 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.6 | 0.005 | 0.0125 | ASP 3
803886 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 1.47639 | 1.47639 | 3.54333 | ASP 4
803958 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.75 | 0.830781 | 1.99388 | ASP 4
804007 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.45 | 0.258879 | 0.62131 | ASP 4
804227 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.75 | 1.01104 | 2.42649 | ASP 4
805365 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.6 | 0.106622 | 0.266554 | ASP 3
805917 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.45 | 0.018232 | 0.0437567 | ASP 2; ASP 4
806075 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.45 | 2.66845 | 6.40429 | ASP 4
806766 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 1.47639 | 1.47639 | 3.54333 | ASP 3
806858 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.75 | 1.76546 | 4.2371 | ASP 3
806940 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.75 | 0.297 | 0.7128 | ASP 3
807684 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.6 | 0.524916 | 1.31229 | ASP 3
807691 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.65 | 1.04436 | 2.61089 | ASP 3
807707 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.6 | 1.3536 | 3.384 | ASP 3
807990 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.3 | 1.23301 | 1.23301 | ASP 3
808015 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.75 | 0.0422289 | 0.101349 | ASP 1; ASP 3

# IfcFlowSegment: Conducto redondo:Xapa d'Acer (10)
Pset_DistributionFlowElementCommon - Reference: Xapa d'Acer; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Xapa d'Acer; ICAT_04-EstatusObra: Nueva construcción
Name (Conducto redondo:Xapa d'Acer:...) | In | Pset_DuctSegmentTypeCommon, Length (m) = Pset_FlowSegmentDuctSegment, Length (m) = ICAT-Llarg (m) | ICAT-Superficie (m2) | Group
441417 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.610018 | 0.191643 | AEWC 2
441617 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0295379 | 0.00927961 | AEWC 2
441789 | P00 - SECTORITZACIÓ I EVACUACIÓ | 2.47128 | 0.776377 | AEWC 2
444374 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.321168 | 0.100898 | AEWC 1
444376 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0295379 | 0.00927961 | AEWC 1
444380 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.82 | 0.57177 | AEWC 1
804519 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.32 | 0.100531 | AE 3
804805 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.025 | 0.00785398 | AE 3
805148 | P00 - SECTORITZACIÓ I EVACUACIÓ | 3.80099 | 1.19412 | AE 3
805165 | P00 - SECTORITZACIÓ I EVACUACIÓ | 1.67872 | 0.527384 | AEWC 2

# IfcFlowSegment: Tipos de tubería:CLI.Aigua (Acer Negre) (261)
Pset_DistributionFlowElementCommon - Reference: CLI.Aigua (Acer Negre); sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: CLI.Aigua (Acer Negre); ICAT_04-EstatusObra: Nueva construcción
Name (Tipos de tubería:CLI.Aigua (Acer Negre):...) | In | Pset_DuctSegmentTypeCommon, Length (m) = Pset_FlowSegmentDuctSegment, Length (m) = ICAT-Llarg (m) | ICAT-Superficie (m2) | Group
775476 | P04 - SECTORITZACIÓ I EVACUACIÓ | 6.21258 | 0.390348 | ACIS 1
775543 | P04 - SECTORITZACIÓ I EVACUACIÓ | 6.21258 | 0.390348 | ACIP 2
