Properties of the parts of a building model (IFC2X3), part 6 of 9

# IfcFlowFitting: M_Codo - Genérico:Estándar (236)
Name (M_Codo - Genérico:Estándar:...) | In | ICAT-Volum (m3) | Group
777429 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 1
777431 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 1
777433 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 1
777435 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 1; AFIS 2
777439 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 1
777441 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 1
777488 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 1
777552 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 1
777627 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 2
777778 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 2
777780 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 2
777912 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 3
777957 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 1
778229 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 2
778231 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 2
778292 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 3
778294 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 3; AFIP 4
778335 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 4
778369 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 2
778523 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 2
779067 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 4
779161 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 3
779165 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 3
779581 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00000925675 | AFIP 6
779583 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00000925675 | AFIS 5
779608 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 6
779665 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 5
779694 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 6
779811 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 5
779846 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 4
779887 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 3
779945 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 5
779947 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 5
779949 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 4
779951 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 4
780261 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 4
780263 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 4
780270 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 5
780272 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 5
780276 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 4
780278 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 5
780280 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 5
781807 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 7
781811 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 6
782194 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 5
782196 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 5
782198 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 6
782200 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 6
782202 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 6
782204 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 7
782242 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 7
782351 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 5
782502 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 6
782504 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 6
782506 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 7
783011 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 5
783013 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 6
783019 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 6
783021 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 6
783025 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 7
783059 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 8
783101 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 11
783225 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 5
783250 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 6
783348 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 6
783374 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 7
783416 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 6
783473 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 7
783509 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 7
783534 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 10
783599 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 5
783607 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 5
783633 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 6
783643 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 6
783698 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 11
783740 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 8
783762 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 8
783770 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 8
783796 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 11
783864 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 11
784121 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 8
784261 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 6
784265 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 5
784269 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 5
784305 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 8
784307 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 8
784338 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 7
784382 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 8
784442 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 6
784605 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 6; AFIP 12
784632 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 7
784884 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00000559177 | ACIP 6
784886 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000050492 | ACIP 6
784905 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 5
784912 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00000602989 | ACIS 5
784914 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 5
784944 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 5
784982 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 6
785459 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 6
785801 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 7
785803 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 13
785826 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 7
785863 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 13
785878 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 13
785880 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 7
785898 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 7
785906 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 7
785934 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 13
785942 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 13
786031 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 6
786039 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 6
786064 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 8
786074 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 8
786185 | Nivel 1 | 0.0000106411 | AFIP 14
786187 | Nivel 1 | 0.0000106411 | AFIS 9
786189 | Nivel 1 | 0.0000106411 | ACIP 9
786191 | Nivel 1 | 0.0000106411 | ACIS 7
786231 | Nivel 1 | 0.0000106411 | AFIS 9
786255 | Nivel 1 | 0.0000106411 | AFIP 14
786507 | Nivel 1 | 0.00000118232 | AFIP 14
786547 | Nivel 1 | 0.00000118232 | AFIS 9
786748 | Nivel 1 | 0.0000106411 | AFIS 9
786759 | Nivel 1 | 0.0000106411 | AFIS 9
786804 | Nivel 1 | 0.0000106411 | AFIP 14
786812 | Nivel 1 | 0.0000106411 | AFIP 14
786860 | Nivel 1 | 0.0000106411 | ACIS 7
786885 | Nivel 1 | 0.0000106411 | ACIP 9
786912 | Nivel 1 | 0.0000106411 | ACIP 9
786980 | Nivel 1 | 0.00000827636 | ACIP 11
787847 | Nivel 1 | 0.0000106411 | AFIP 16
787851 | Nivel 1 | 0.0000106411 | ACIS 9
787913 | Nivel 1 | 0.0000106411 | AFIP 16
788034 | Nivel 1 | 0.0000106411 | AFIS 10
788078 | Nivel 1 | 0.0000106412 | AFIS 10
788139 | Nivel 1 | 0.0000106411 | AFIP 16
788175 | Nivel 1 | 0.0000106411 | ACIS 9
788199 | Nivel 1 | 0.0000106411 | ACIP 12
788225 | Nivel 1 | 0.0000106411 | ACIP 12
788250 | Nivel 1 | 0.0000106411 | ACIS 9
788672 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000934049 | AFIP 15
788674 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000934049 | AFIS 11
788937 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000931523 | ACIP 13
788941 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000931523 | ACIS 10
788983 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 11; AFIP 17
788994 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 17
789021 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 15
789031 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 15
789129 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 13
789155 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 10
789348 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 13
789352 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 10
789689 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 10
789696 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106165 | ACIS 10
789701 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 13
789705 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106166 | ACIP 13
790216 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 14
790218 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 11
790300 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 12
790302 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 18
790358 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 12
790390 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 12
790424 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 18
790432 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 18
790477 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 12; AFIP 19
790486 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 19
790516 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 18
790555 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 18
790577 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 11
790585 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 11
790631 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 14
790639 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 14
790812 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 13
790876 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 13
790944 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 20
790946 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 20
790970 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 20
791085 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 12
791115 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 15
791137 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 12
791149 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 12
791185 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 15
791251 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 13
791255 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 16
791259 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 13
791263 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIS 13
791267 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | ACIP 16
791320 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIS 14
791324 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 21
791326 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000106411 | AFIP 21
794545 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 4
794662 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 4
794670 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 4
794672 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 4
795260 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 2
795270 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 2
795310 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 2
795318 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 2
795401 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 2
795409 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 2
795411 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00000444202 | AFS 2
795460 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.000944419 | SAN_Fecal Aeri 2
795470 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.000938407 | SAN_Fecal Aeri 2
795553 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.000944421 | SAN_Fecal Aeri 2

# IfcFlowFitting: M_Codo rectangular - Radio:.55 W (36)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: .55 W; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: .55 W; ICAT_04-EstatusObra: Nueva construcción
Name (M_Codo rectangular - Radio:.55 W:...) | In | ICAT-Volum (m3) | Group
400200 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.0529158 | Mecánica Aire Aportació PK 1
408168 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.052843 | ASP 5
408169 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.052843 | ASP 5
456154 | Nivel 1 | 0.027376 | AI 19
456475 | Nivel 1 | 0.027376 | AI 19
456620 | Nivel 1 | 0.0323975 | AI 19
456630 | Nivel 1 | 0.0323975 | AI 19
457831 | Nivel 1 | 0.0158747 | AI 19
458575 | Nivel 1 | 0.000863872 | Mecánica Aire de retorno 43
461829 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0466529 | AI 21
461850 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0466529 | AI 21
462322 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0161988 | AI 21
462330 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0161988 | AI 21
463805 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00518329 | Mecánica Aire de retorno 8
463812 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00518329 | Mecánica Aire de retorno 8
464685 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00809938 | Mecánica Aire de retorno 8
465852 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0466529 | Mecánica Aire de retorno 8
466041 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0269548 | Mecánica Aire de retorno 8
466056 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0269548 | Mecánica Aire de retorno 8
467250 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0370412 | AI 23
467293 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0370412 | AI 23
471254 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0591275 | AI 18
471303 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0591275 | AI 18
480795 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00291567 | Mecánica Aire de retorno 17
767560 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0138221 | AE 1; Mecánica Aire de retorno 45
767799 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0138221 | Mecánica Aire de retorno 45
771398 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0784019 | AI 24
780642 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00340169 | Mecánica Aire de retorno 8
780655 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00340169 | Mecánica Aire de retorno 8
780735 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00350245 | Mecánica Aire de retorno 8
780738 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00350245 | Mecánica Aire de retorno 8
790010 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.000711079 | AI 22
790013 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.000711079 | AI 22
790106 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.000711079 | AI 22
790108 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.000711079 | AI 22
808485 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.218684 | ASP 1

# IfcFlowFitting: M_Codo rectangular - Radio:1 W (158)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1 W; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 1 W; ICAT_04-EstatusObra: Nueva construcción
Name (M_Codo rectangular - Radio:1 W:...) | In | ICAT-Volum (m3) | Group
351363 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0098174 | AI 1
351839 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0098174 | AI 1
395778 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0386812 | ASP 2
395781 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0386812 | ASP 2
397334 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0386812 | ASP 1
398223 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.0157079 | ASP 1
398314 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.0157079 | ASP 1
401585 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0245435 | ASP 5
402218 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0353428 | ASP 5
402562 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0245435 | ASP 5
402741 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0245435 | ASP 5
403837 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.137445 | Mecánica Aire Aportació PK 1
404201 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0275098 | Mecánica Aire Aportació PK 1
404208 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0275098 | Mecánica Aire Aportació PK 1
404842 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.137445 | Mecánica Aire Aportació PK 1
404843 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0962111 | Mecánica Aire Aportació PK 1
405223 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0294522 | ASP 5
405745 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0102439 | ASP 5
405746 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0102439 | ASP 5
407901 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0962111 | Mecánica Aire Aportació PK 1
408749 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.17495 | ASP 5
408775 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0367818 | ASP 5
408993 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0367818 | ASP 5
428566 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.0261798 | AEPK 1
428604 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.0261798 | AEPK 1
435014 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.0229074 | Mecánica Aire Aportació PK EI 2
435015 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.0229074 | Mecánica Aire Aportació PK EI 2
437681 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.137445 | Mecánica Aire Aportació PK EI 1
438783 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.142549 | AI 24
439456 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0245435 | AI 24
443807 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0125663 | Mecánica Aire de retorno 55
444196 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0125663 | Mecánica Aire de retorno 55
444296 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0125663 | Mecánica Aire de retorno 55
453753 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00942474 | AI 22
454066 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0106814 | Mecánica Aire de retorno 5
454391 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | Mecánica Aire de retorno 3
454665 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0166896 | Mecánica Aire de retorno 4
455320 | Nivel 1 | 0.0643546 | AI 19
455333 | Nivel 1 | 0.0643546 | AI 19
458769 | Nivel 1 | 0.000209439 | Mecánica Aire de retorno 43
458927 | Nivel 1 | 0.0014873 | Mecánica Aire de retorno 20
459416 | Nivel 1 | 0.000261799 | Mecánica Aire de retorno 9
459446 | Nivel 1 | 0.00143114 | Mecánica Aire de retorno 9
459603 | Nivel 1 | 0.00157075 | Mecánica Aire de retorno 34
459628 | Nivel 1 | 0.00157075 | Mecánica Aire de retorno 36
459637 | Nivel 1 | 0.00157075 | Mecánica Aire de retorno 35
459676 | Nivel 1 | 0.00157075 | Mecánica Aire de retorno 38
459679 | Nivel 1 | 0.00157075 | Mecánica Aire de retorno 37
459737 | Nivel 1 | 0.00157075 | Mecánica Aire de retorno 40
459740 | Nivel 1 | 0.00157075 | Mecánica Aire de retorno 39
461177 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0673479 | AI 21
461186 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0673479 | AI 21
461361 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00628316 | AI 21
461718 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0207345 | AI 21
461729 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0207345 | AI 21
463226 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00825097 | Mecánica Aire de retorno 7
463445 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | Mecánica Aire de retorno 10
463555 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | Mecánica Aire de retorno 11
463578 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | Mecánica Aire de retorno 12
464373 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0168964 | Mecánica Aire de retorno 8
464722 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0168964 | Mecánica Aire de retorno 8
465760 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0141372 | Mecánica Aire de retorno 8
465798 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0141372 | Mecánica Aire de retorno 8
467210 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0035341 | AI 23
467672 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00628316 | AI 23
467724 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00628316 | AI 23
468519 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | AI 23
468529 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | AI 23
468594 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00530115 | AI 23
468825 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | Mecánica Aire de retorno 13
468897 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | Mecánica Aire de retorno 33
469623 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | Mecánica Aire de retorno 16
469632 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000209439 | Mecánica Aire de retorno 16
469856 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0045945 | Mecánica Aire de retorno 17
469899 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | Mecánica Aire de retorno 17
469901 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000209439 | Mecánica Aire de retorno 17
469961 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00530115 | Mecánica Aire de retorno 17
470035 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00942474 | Mecánica Aire de retorno 15
470615 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | Mecánica Aire de retorno 23
470670 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | Mecánica Aire de retorno 42
471932 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00530115 | AI 18
472092 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0376992 | AI 18
472513 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00736309 | AI 18
472520 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00736309 | AI 18
472624 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00530115 | Mecánica Aire de retorno 27
472653 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00530115 | Mecánica Aire de retorno 30
472904 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00136648 | Mecánica Aire de retorno 53
472967 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | Mecánica Aire de retorno 29
473377 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00628316 | AI 23
473851 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00628316 | AI 23
474422 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000630259 | AI 23
474423 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.000630259 | AI 23
477051 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | Mecánica Aire de retorno 31
479197 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00157075 | Mecánica Aire de retorno 14
485453 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00628316 | AI 21
485803 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000558468 | AI 21
485814 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000558468 | AI 21
486865 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0212057 | Mecánica Aire de retorno 8
486924 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0212057 | Mecánica Aire de retorno 8
489841 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.018447 | AI 21
489878 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00122608 | AI 21
489885 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00942474 | AI 21
490132 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00081739 | AI 21
490302 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00081739 | AI 21
491030 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.000684279 | Mecánica Aire de retorno 19
491039 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00108206 | Mecánica Aire de retorno 19
498955 | Nivel 1 | 0.00530115 | AI 19
499864 | Nivel 1 | 0.00492267 | AI 19
500035 | Nivel 1 | 0.000378584 | AI 19
500222 | Nivel 1 | 0.000523572 | AI 19
500297 | Nivel 1 | 0.000523572 | AI 19
503330 | Nivel 1 | 0.00157075 | Mecánica Aire de retorno 41
503529 | Nivel 1 | 0.00157075 | Mecánica Aire de retorno 63
503554 | Nivel 1 | 0.000226892 | Mecánica Aire de retorno 63
503597 | Nivel 1 | 0.00157075 | Mecánica Aire de retorno 64
503600 | Nivel 1 | 0.000226892 | Mecánica Aire de retorno 64
506972 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00530115 | AI 18
509272 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00117356 | Mecánica Aire de retorno 21
510292 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0961321 | AI 22
512593 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0147261 | AI 22
512692 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00942474 | AI 22
514887 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0166896 | Mecánica Aire de retorno 28
555969 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0327118 | Mecánica Aire de retorno 1
556140 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0106814 | Mecánica Aire de retorno 5
556149 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0106814 | Mecánica Aire de retorno 5
659272 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0119991 | Mecánica Aire de retorno 55
659323 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00763586 | Mecánica Aire de retorno 55
659334 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00981746 | Mecánica Aire de retorno 55
680976 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0276728 | AI 22
680977 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0276728 | AI 22
681043 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0133518 | AI 22
681044 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0133518 | AI 22
757194 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00136642 | Mecánica Aire de retorno 22
762415 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0386812 | ASP 1
763997 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00471239 | AE 2
764690 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00314159 | AP 1
765089 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0113062 | AP 1
765092 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0113062 | AP 1
767327 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0251326 | AI 25
769837 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00981746 | Mecánica Aire de retorno 55
771544 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00628316 | AI 24
785150 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00353427 | AI 21
785217 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00353427 | AI 21
785230 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0040055 | AI 21
785242 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0040055 | AI 21
796780 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.238568 | ASP 2
798466 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0795214 | ASP 1
798480 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0795214 | ASP 1
804003 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.397605 | ASP 4
804014 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.238568 | ASP 4
804239 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.0862417 | ASP 4
806513 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.0862417 | ASP 4
806837 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.397605 | ASP 3
806874 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.238568 | ASP 3
807702 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.132876 | ASP 3
807740 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.132876 | ASP 3
808364 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.0188495 | ASP 3
808386 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0282743 | ASP 1

# IfcFlowFitting: M_Codo redondo:1 D (6)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1 D; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 1 D; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Volum: 0.00123366 m3
Name (M_Codo redondo:1 D:...) | In | Group
441693 | P00 - SECTORITZACIÓ I EVACUACIÓ | AEWC 2
444378 | P0A - SECTORITZACIÓ I EVACUACIÓ | AEWC 1
444382 | P0A - SECTORITZACIÓ I EVACUACIÓ | AEWC 1
804840 | P00 - SECTORITZACIÓ I EVACUACIÓ | AE 3
804973 | P00 - SECTORITZACIÓ I EVACUACIÓ | AEWC 2
805173 | P00 - SECTORITZACIÓ I EVACUACIÓ | AE 3

# IfcFlowFitting: M_Cruz rectangular:Estándar (11)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Estándar; ICAT_04-EstatusObra: Nueva construcción
Name (M_Cruz rectangular:Estándar:...) | In | ICAT-Volum (m3) | Group
351672 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0651875 | AI 1
451989 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.02295 | AI 22
452391 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.02295 | AI 22
452443 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.02295 | AI 22
452911 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.017 | AI 22
466347 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.07275 | AI 21
467527 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.02025 | AI 23
468112 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.02025 | AI 23
471957 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0958125 | AI 18
474111 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0615 | AI 23
499018 | Nivel 1 | 0.0144375 | AI 19

# IfcFlowFitting: M_Remate rectangular:Estándar (139)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Estándar; ICAT_04-EstatusObra: Nueva construcción
Name (M_Remate rectangular:Estándar:...) | In | ICAT-Volum (m3) | Group
355818 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | AI 1
356009 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | AI 1
356437 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | AI 1
402957 | PS2 - SECTORITZACIÓ I EVACUACIÓ | 0.0015625 | ASP 5
436521 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.004375 | Mecánica Aire Aportació PK EI 2
438072 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.005 | AEPK 1
474861 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 23
475016 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 23
475035 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 23
475208 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 23
475263 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | AI 23
478398 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 31
478954 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 33
479354 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 14
479471 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 14
479681 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | Mecánica Aire de retorno 15
479809 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | Mecánica Aire de retorno 15
480565 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 17
480597 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 16
481060 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0005625 | Mecánica Aire de retorno 17
483379 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | AI 23
484768 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 21
485094 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 21
485380 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | AI 21
485655 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 21
486227 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | AI 21
490510 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 21
490651 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 21
490955 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | AI 21
491364 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 19
491365 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 19
491623 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | Mecánica Aire de retorno 7
491737 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | Mecánica Aire de retorno 7
492259 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0005625 | Mecánica Aire de retorno 8
492651 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0005625 | Mecánica Aire de retorno 8
492835 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0005625 | Mecánica Aire de retorno 8
492975 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0005625 | Mecánica Aire de retorno 8
493306 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | Mecánica Aire de retorno 8
493698 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 10
493699 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 11
493700 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 12
494062 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 10
494063 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 11
494064 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 12
494347 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0005625 | Mecánica Aire de retorno 8
498378 | Nivel 1 | 0.0005 | AI 19
500676 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 20
500907 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 9
502039 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 38
502068 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 37
502097 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 40
502126 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 39
502151 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 41
502168 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 35
502185 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 36
502206 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 34
502967 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 9
503057 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 20
503084 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 34
503128 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 35
503154 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 36
503181 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 38
503208 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 37
503226 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 40
503253 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 39
503388 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 41
503865 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 63
503866 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 64
503879 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 63
503880 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 64
504214 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 62
504370 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 62
504475 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 61
504476 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 61
504745 | Nivel 1 | 0.00025 | Mecánica Aire de retorno 43
505512 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0013125 | AI 18
506065 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0009375 | AI 18
506330 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | AI 18
506419 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 18
507241 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 53
507502 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 29
507756 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 29
507797 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 53
507902 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0005625 | Mecánica Aire de retorno 30
508149 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0005625 | Mecánica Aire de retorno 54
508150 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0005625 | Mecánica Aire de retorno 54
508287 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0005625 | Mecánica Aire de retorno 27
508489 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0005625 | Mecánica Aire de retorno 27
508724 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0005625 | Mecánica Aire de retorno 30
509746 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | AI 22
511219 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 22
511220 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 22
511823 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 22
511824 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 22
511949 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 22
511964 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 22
512156 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 22
512171 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 22
512186 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 22
513375 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 3
514134 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0010625 | Mecánica Aire de retorno 4
514519 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 3
514733 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0010625 | Mecánica Aire de retorno 4
514888 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0010625 | Mecánica Aire de retorno 28
514894 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0010625 | Mecánica Aire de retorno 28
514897 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0010625 | Mecánica Aire de retorno 28
515124 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00085 | Mecánica Aire de retorno 5
515569 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0014875 | Mecánica Aire de retorno 1
515750 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0014875 | Mecánica Aire de retorno 1
516106 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 3
516781 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00125 | AI 24
516843 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00125 | AI 24
517112 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0015625 | AI 24
517693 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 24
517772 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 24
517990 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 24
518653 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.001 | Mecánica Aire de retorno 55
518669 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.001 | Mecánica Aire de retorno 55
518705 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0005625 | Mecánica Aire de retorno 55
528256 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0009375 | AI 23
556178 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00085 | Mecánica Aire de retorno 5
574840 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.000625 | AI 1
659816 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 24
754023 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0005 | AI 18
755324 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | AI 1
755596 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 13
756814 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0010625 | Mecánica Aire de retorno 4
757202 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 23
757203 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 23
757204 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 42
757205 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 42
757206 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 22
757207 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00025 | Mecánica Aire de retorno 22
757644 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.000625 | AI 1
757835 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.00075 | Mecánica Aire de retorno 21
764958 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00225 | AE 2
764959 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0015 | AP 1
765513 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.002 | AI 25
768103 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.002 | Mecánica Aire de retorno 45

# IfcFlowFitting: M_Te - Genérica:Estándar (13)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Estándar; ICAT_04-EstatusObra: Nueva construcción
Name (M_Te - Genérica:Estándar:...) | In | ICAT-Volum (m3) | Group
688289 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0000109205 | AFS 3
696631 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00372642 | SAN_Fecal Aeri 1
697029 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00372732 | SAN_Fecal Enterrat 1
697348 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00405658 | SAN_Fecal Enterrat 1
782237 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000240538 | AFIP 7
782272 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000240538 | AFIS 6
782308 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000240538 | ACIP 6
782347 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000240538 | ACIS 5
783055 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000240538 | AFIP 7
783097 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000240538 | AFIS 6
783179 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000240538 | ACIS 5
784297 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0000240538 | ACIP 6
795225 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0000109205 | AFS 2

# IfcFlowFitting: M_Te rectangular:Estándar (62)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Estándar; ICAT_04-EstatusObra: Nueva construcción
Name (M_Te rectangular:Estándar:...) | In | ICAT-Volum (m3) | Group
351037 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0283125 | AI 1
351299 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.013 | AI 1
352104 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0285 | AI 1
398315 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.01925 | ASP 1
402385 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0240625 | ASP 5
438824 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0945 | AI 24
438968 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.011 | AI 24
439130 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.046875 | AI 24
439415 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.046875 | AI 24
439767 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0203125 | AI 24
443770 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0080625 | Mecánica Aire de retorno 55
444183 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.011 | Mecánica Aire de retorno 55
451289 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.095625 | AI 22
455357 | Nivel 1 | 0.0441875 | AI 19
455489 | Nivel 1 | 0.007125 | AI 19
456562 | Nivel 1 | 0.0301875 | AI 19
456986 | Nivel 1 | 0.043125 | AI 19
457368 | Nivel 1 | 0.0283125 | AI 19
457424 | Nivel 1 | 0.0110625 | AI 19
457609 | Nivel 1 | 0.013875 | AI 19
458020 | Nivel 1 | 0.0140625 | AI 19
460408 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0441875 | AI 21
460527 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.007125 | AI 21
461399 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00825 | AI 21
462183 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.043125 | AI 21
462457 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.043125 | AI 21
464679 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0279375 | Mecánica Aire de retorno 8
464743 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0140625 | Mecánica Aire de retorno 8
465055 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0241875 | Mecánica Aire de retorno 8
465708 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0185625 | Mecánica Aire de retorno 8
466286 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.013875 | AI 21
466569 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.013875 | AI 21
466832 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.013875 | AI 21
466984 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.02325 | AI 21
467077 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0251562 | AI 23
467199 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.003375 | AI 23
467846 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00825 | AI 23
468367 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.006375 | AI 23
468614 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0050625 | AI 23
469955 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0050625 | Mecánica Aire de retorno 17
471539 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0195 | AI 18
471716 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.00825 | AI 18
471859 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.006375 | AI 18
472361 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.035875 | AI 18
473837 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0055 | AI 23
485691 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0188125 | AI 21
486975 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.016875 | Mecánica Aire de retorno 8
490125 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.012 | AI 21
490297 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.012 | AI 21
498731 | Nivel 1 | 0.0223125 | AI 19
499310 | Nivel 1 | 0.0050625 | AI 19
499340 | Nivel 1 | 0.0050625 | AI 19
499373 | Nivel 1 | 0.0140625 | AI 19
499404 | Nivel 1 | 0.0140625 | AI 19
499428 | Nivel 1 | 0.0140625 | AI 19
499911 | Nivel 1 | 0.0050625 | AI 19
513938 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0138125 | Mecánica Aire de retorno 4
514890 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0138125 | Mecánica Aire de retorno 28
516153 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00175 | Mecánica Aire de retorno 3
756504 | Nivel 1 | 0.013875 | AI 19
771538 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.04275 | AI 24
797957 | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 0.1005 | ASP 3

# IfcFlowFitting: M_Te redonda:Estándar, M_Te redonda:Estándar:805164
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Estándar; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Volum: 0.00202278 m3
Group: AEWC 2

# IfcFlowFitting: M_Transición - Genérica:Estándar (6)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Estándar; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Llarg: 0.0282938 m
Name (M_Transición - Genérica:Estándar:...) | In | ICAT-Superficie (m2) | ICAT-Volum (m3) | Group
696640 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0118331 | 0.000141996 | SAN_Fecal Aeri 1
697037 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0121868 | 0.000141996 | SAN_Fecal Enterrat 1
697112 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.018471 | 0.000279528 | SAN_Fecal Enterrat 1
697357 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0188766 | 0.000279528 | SAN_Fecal Enterrat 1
795445 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.018471 | 0.000279528 | SAN_Fecal Aeri 2
795732 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.018471 | 0.000279532 | SAN_Fecal Aeri 2

# IfcFlowFitting: M_Transición de rectangular a redondo - Ángulo:100 grados, M_Transición de rectangular a redondo - Ángulo:100 grados:475400
In: P03 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 100 grados; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 100 grados; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0625 m2; ICAT-Volum: 0.00362682 m3
Group: AI 23

# IfcFlowFitting: M_Transición de rectangular a redondo - Ángulo:60 grados (72)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 60 grados; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 60 grados; ICAT_04-EstatusObra: Nueva construcción
Name (M_Transición de rectangular a redondo - Ángulo:60 grados:...) | In | ICAT-Superficie (m2) | ICAT-Volum (m3) | Group
473574 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 23
474504 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 23
474810 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 23
474992 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 23
475100 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 23
475432 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 23
475462 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 23
475621 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 23
480113 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 23
484340 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 21
484611 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 21
484659 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 21
484842 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 21
485016 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 21
485286 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 21
485590 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 21
486169 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.04 | 0.00185693 | AI 21
486421 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 21
490460 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 21
490639 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 21
490930 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 21
497139 | Nivel 1 | 0.0625 | 0.00362682 | AI 19
497211 | Nivel 1 | 0.0625 | 0.00362682 | AI 19
497239 | Nivel 1 | 0.0625 | 0.00362682 | AI 19
497373 | Nivel 1 | 0.0625 | 0.00362682 | AI 19
497403 | Nivel 1 | 0.0625 | 0.00362682 | AI 19
497435 | Nivel 1 | 0.0625 | 0.00362682 | AI 19
498086 | Nivel 1 | 0.0625 | 0.00362682 | AI 19
498259 | Nivel 1 | 0.0625 | 0.00362682 | AI 19
498480 | Nivel 1 | 0.04 | 0.00185693 | AI 19
505345 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 18
505376 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 18
505409 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 18
505445 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 18
505662 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 18
505689 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 18
505721 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 18
505800 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 18
506107 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0466178 | 0.00200755 | AI 18
506269 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 18
506301 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 18
506494 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 18
509556 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.04 | 0.00185693 | AI 22
509584 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.04 | 0.00185693 | AI 22
509612 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.04 | 0.00185693 | AI 22
509734 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
509845 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
510464 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
511049 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
511178 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
511680 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
511789 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
512000 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
512032 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
512248 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
512864 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
513015 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
513138 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
513166 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 22
516689 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 24
516719 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 24
516768 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 24
516969 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 24
516997 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 24
517026 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 24
517236 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 24
517264 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 24
517292 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 24
517617 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 24
517852 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 24
518080 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 24
659908 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0625 | 0.00362682 | AI 24

# IfcFlowFitting: M_Transición rectangular - Ángulo:100 grados (5)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 100 grados; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 100 grados; ICAT_04-EstatusObra: Nueva construcción
Name (M_Transición rectangular - Ángulo:100 grados:...) | In | ICAT-Superficie (m2) | ICAT-Volum (m3) | Group
398446 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0719581 | 0.00619492 | ASP 1
404831 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.32121 | 0.0535582 | Mecánica Aire Aportació PK 1
408605 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.59154 | 0.1108 | ASP 6
498642 | Nivel 1 | 0.0749453 | 0.00566392 | AI 19
498878 | Nivel 1 | 0.049518 | 0.00314662 | AI 19

# IfcFlowFitting: M_Transición rectangular - Ángulo:45 grados, M_Transición rectangular - Ángulo:45 grados:402220
In: P04 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 45 grados; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 45 grados; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0544877 m2; ICAT-Volum: 0.0034375 m3
Group: ASP 5

# IfcFlowFitting: M_Transición rectangular - Ángulo:60 grados (151)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 60 grados; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 60 grados; ICAT_04-EstatusObra: Nueva construcción
Name (M_Transición rectangular - Ángulo:60 grados:...) | In | ICAT-Superficie (m2) | ICAT-Volum (m3) | Group
351232 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0518241 | 0.0024357 | AI 1
351253 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0829109 | 0.00617043 | AI 1
351284 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0409091 | 0.00189443 | AI 1
351349 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0459808 | 0.00259808 | AI 1
351674 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.048818 | 0.0015832 | AI 1
351716 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0919514 | 0.00795661 | AI 1
351816 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0334539 | 0.0014975 | AI 1
352113 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0640609 | 0.00454663 | AI 1
352169 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0640609 | 0.00454663 | AI 1
352229 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0354515 | 0.0016238 | AI 1
352406 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0354515 | 0.0016238 | AI 1
355312 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0518241 | 0.0024357 | AI 1
355542 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.162121 | 0.0155885 | AI 1
395892 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.223318 | 0.0289803 | ASP 2
397456 | PS2 - SECTORITZACIÓ I EVACUACIÓ | 0.223967 | 0.0289803 | ASP 1
405499 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.186499 | 0.0220716 | ASP 5
408994 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.195401 | 0.0215785 | ASP 5
428606 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.719543 | 0.189708 | AEPK 1
432552 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.373837 | 0.0734476 | Mecánica Aire Aportació PK EI 2
434250 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.611033 | 0.135204 | AEPK 2
434298 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.611033 | 0.135204 | AEPK 3
435400 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.373837 | 0.0734476 | Mecánica Aire Aportació PK EI 1
437662 | PS1 - SECTORITZACIÓ I EVACUACIÓ | 0.178855 | 0.0232203 | Mecánica Aire Aportació PK 1
438930 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.209434 | 0.0293005 | AI 24
439471 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.16896 | 0.0225527 | AI 24
452455 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.120282 | 0.0117779 | AI 22
453677 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.143716 | 0.0146791 | AI 22
454578 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.282197 | 0.0314079 | AI 22
455468 | Nivel 1 | 0.0331317 | 0.00105547 | AI 19
456497 | Nivel 1 | 0.0888876 | 0.00475412 | AI 19
456599 | Nivel 1 | 0.12907 | 0.0112042 | AI 19
456995 | Nivel 1 | 0.0599431 | 0.00308522 | AI 19
457085 | Nivel 1 | 0.149135 | 0.0147766 | AI 19
457631 | Nivel 1 | 0.0770513 | 0.00649519 | AI 19
460502 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0331317 | 0.00105547 | AI 21
460583 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0136214 | 0.000541266 | AI 21
463962 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0303678 | 0.00146142 | Mecánica Aire de retorno 8
464723 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.118825 | 0.0102299 | Mecánica Aire de retorno 8
466349 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.198564 | 0.0207846 | AI 21
466352 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0749618 | 0.00246276 | AI 21
466861 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0136214 | 0.000541266 | AI 21
467162 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0252743 | 0.00133963 | AI 23
468378 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.139683 | 0.0136399 | AI 23
468471 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0170813 | 0.000685603 | AI 23
469977 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0170813 | 0.000685603 | Mecánica Aire de retorno 17
471959 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0540468 | 0.00175911 | AI 18
472081 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0841731 | 0.00635085 | AI 18
472222 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0894615 | 0.00779423 | AI 18
472408 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.379488 | 0.0462782 | AI 18
472409 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0540468 | 0.00175911 | AI 18
472499 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0589279 | 0.00423992 | AI 18
473852 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.133643 | 0.0116913 | AI 23
474113 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0749618 | 0.00246276 | AI 23
474257 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.254488 | 0.0277669 | AI 23
474647 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0245365 | 0.00108253 | AI 23
474648 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0245365 | 0.00108253 | AI 23
474927 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0245365 | 0.00108253 | AI 23
475206 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0245365 | 0.00108253 | AI 23
478465 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0342121 | 0.00200719 | Mecánica Aire de retorno 13
481112 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0342121 | 0.00200719 | Mecánica Aire de retorno 16
482411 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0272902 | 0.00138023 | AI 23
482620 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0272902 | 0.00138023 | AI 23
482829 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0183941 | 0.000518713 | AI 23
483161 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0301027 | 0.00166439 | AI 23
483186 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0301027 | 0.00166439 | AI 23
484632 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0445927 | 0.00274241 | AI 21
484719 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0245365 | 0.00108253 | AI 21
484727 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0245365 | 0.00108253 | AI 21
485709 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.018338 | 0.000893089 | AI 21
490130 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0245365 | 0.00108253 | AI 21
490303 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0245365 | 0.00108253 | AI 21
490677 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0479006 | 0.0032476 | AI 21
491996 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0461034 | 0.00292284 | Mecánica Aire de retorno 8
492086 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0461034 | 0.00292284 | Mecánica Aire de retorno 8
495404 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0342121 | 0.00200719 | AI 21
495806 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0136214 | 0.000541266 | AI 21
495807 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0342121 | 0.00200719 | AI 21
496032 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0136214 | 0.000541266 | AI 21
496033 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0342121 | 0.00200719 | AI 21
496317 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0342121 | 0.00200719 | AI 21
496504 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.114282 | 0.0103923 | AI 21
496505 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.133643 | 0.0116913 | AI 21
496506 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.133643 | 0.0116913 | AI 21
496507 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0963814 | 0.00714471 | AI 21
496966 | Nivel 1 | 0.0445927 | 0.00274241 | AI 19
497960 | Nivel 1 | 0.0245365 | 0.00108253 | AI 19
498643 | Nivel 1 | 0.0301027 | 0.00166439 | AI 19
498707 | Nivel 1 | 0.0301027 | 0.00166439 | AI 19
498879 | Nivel 1 | 0.0301027 | 0.00166439 | AI 19
498956 | Nivel 1 | 0.0301027 | 0.00166439 | AI 19
499585 | Nivel 1 | 0.0301027 | 0.00166439 | AI 19
499607 | Nivel 1 | 0.0301027 | 0.00166439 | AI 19
499629 | Nivel 1 | 0.0301027 | 0.00166439 | AI 19
499651 | Nivel 1 | 0.0301027 | 0.00166439 | AI 19
499677 | Nivel 1 | 0.0301027 | 0.00166439 | AI 19
499707 | Nivel 1 | 0.0301027 | 0.00166439 | AI 19
499865 | Nivel 1 | 0.0301027 | 0.00166439 | AI 19
500036 | Nivel 1 | 0.0301027 | 0.00166439 | AI 19
500108 | Nivel 1 | 0.0136214 | 0.000541266 | AI 19
500109 | Nivel 1 | 0.0342121 | 0.00200719 | AI 19
500170 | Nivel 1 | 0.0136214 | 0.000541266 | AI 19
500171 | Nivel 1 | 0.0342121 | 0.00200719 | AI 19
500206 | Nivel 1 | 0.0254904 | 0.00129904 | AI 19
500298 | Nivel 1 | 0.0342121 | 0.00200719 | AI 19
505116 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0383605 | 0.00123138 | AI 18
505190 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.133643 | 0.0116913 | AI 18
506417 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0245365 | 0.00108253 | AI 18
506683 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0301027 | 0.00166439 | AI 18
506971 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0301027 | 0.00166439 | AI 18
509273 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0212066 | 0.000631477 | Mecánica Aire de retorno 21
510293 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.102881 | 0.00809734 | AI 22
511402 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0306541 | 0.00163679 | AI 22
511425 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0306541 | 0.00163679 | AI 22
511524 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0306541 | 0.00163679 | AI 22
511555 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0306541 | 0.00163679 | AI 22
511908 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0306541 | 0.00163679 | AI 22
511923 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0306541 | 0.00163679 | AI 22
512285 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.031996 | 0.00156245 | AI 22
512295 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0260507 | 0.00069282 | AI 22
