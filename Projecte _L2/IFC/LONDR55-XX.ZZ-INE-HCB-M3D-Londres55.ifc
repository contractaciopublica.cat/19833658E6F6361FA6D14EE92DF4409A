Properties of the parts of a building model (IFC2X3), part 1 of 9

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 7eb33999-3cc5-4eeb-b72a-9d10b99e57be, VersionGUID: 8c31bb40-79f6-4599-834a-c67259700561, NumberOfSaves: 430], CoordinateReference [CoordinateBase: Coordenadas compartidas, ProjectSite: Interna]
File name: LONDR55-XX.ifc
Time: 2025-12-04T17:06:05+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.4.20.11 (ESP) - IFC 25.4.20.11

# IfcProject, 21002
LongName: PROJECTE EXECUTIU REFORMA DE L'EDIFICI LONDRES 55; Phase: PE

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 10
ICAT-Identificacio - ICAT-Projecte: PROJECTE EXECUTIU REFORMA DE L'EDIFICI LONDRES 55; ICAT-Fase del projecte: PE

# IfcBuildingStorey: Nivel:LL.ARQ - VIS - Trazo Punto gris (Absoluto) (7)
Name | LongName | Elevation (m)
Nivel 1 | Nivel 1 | 6.25
P02 - SECTORITZACIÓ I EVACUACIÓ | P02 - SECTORITZACIÓ I EVACUACIÓ | 9.26
P03 - SECTORITZACIÓ I EVACUACIÓ | P03 - SECTORITZACIÓ I EVACUACIÓ | 12.27
P04 - SECTORITZACIÓ I EVACUACIÓ | P04 - SECTORITZACIÓ I EVACUACIÓ | 15.28
P05 - SECTORITZACIÓ I EVACUACIÓ | P05 - SECTORITZACIÓ I EVACUACIÓ | 18.29
PsotaC - SECTORITZACIÓ I EVACUACIÓ | PsotaC - SECTORITZACIÓ I EVACUACIÓ | 21.2
PC | PC | 24.37

# IfcBuildingStorey: Nivel:LL.ARQ - VIS - Trazo Punto gris (Relativo) (4)
Name | LongName | Elevation (m)
PS2 - SECTORITZACIÓ I EVACUACIÓ | PS2 - SECTORITZACIÓ I EVACUACIÓ | -6.4
PS1 - SECTORITZACIÓ I EVACUACIÓ | PS1 - SECTORITZACIÓ I EVACUACIÓ | -3.47
P00 - SECTORITZACIÓ I EVACUACIÓ | P00 - SECTORITZACIÓ I EVACUACIÓ | -1.32976e-12
P0A - SECTORITZACIÓ I EVACUACIÓ | P0A - SECTORITZACIÓ I EVACUACIÓ | 3.35

# IfcBuildingElementProxy: ZYR_03.04.03 Fancoil terra:FC01(1415), ZYR_03.04.03 Fancoil terra:FC01(1415):778431
In: P04 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: FC01(1415); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: FC01(1415); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.95625 m2; ICAT-Volum: 0.265312 m3

# IfcBuildingElementProxy: ZYR_03.04.03 Fancoil terra:FC01(630) (7)
Type - Material: <Unnamed>
Classification: 50.30.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: FC01(630); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: FC01(630); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.6875 m2; ICAT-Volum: 0.225 m3
Name (ZYR_03.04.03 Fancoil terra:FC01(630):...) | In
780058 | P03 - SECTORITZACIÓ I EVACUACIÓ
780138 | P03 - SECTORITZACIÓ I EVACUACIÓ
780178 | P03 - SECTORITZACIÓ I EVACUACIÓ
788281 | Nivel 1
788388 | Nivel 1
788438 | Nivel 1
788486 | Nivel 1

# IfcBuildingElementProxy: ZYR_03.04.03 Fancoil terra:FC02(1200), ZYR_03.04.03 Fancoil terra:FC02(1200):773515
In: P05 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: FC02(1200); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: FC02(1200); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.6875 m2; ICAT-Volum: 0.225 m3

# IfcBuildingElementProxy: ZYR_03.04.03 Fancoil terra:FC02(440), ZYR_03.04.03 Fancoil terra:FC02(440):785088
In: P02 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: FC02(440); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: FC02(440); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.41875 m2; ICAT-Volum: 0.184687 m3

# IfcBuildingElementProxy: ZYR_03.04.03 Fancoil terra:FC03(1415) (2)
Type - Material: <Unnamed>
Classification: 50.30.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: FC03(1415); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: FC03(1415); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.95625 m2; ICAT-Volum: 0.265312 m3
Name (ZYR_03.04.03 Fancoil terra:FC03(1415):...) | In
773623 | P05 - SECTORITZACIÓ I EVACUACIÓ
778407 | P04 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_03.04.03 Fancoil terra:FC03(430), ZYR_03.04.03 Fancoil terra:FC03(430):786003
In: P03 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: FC03(430); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: FC03(430); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.6875 m2; ICAT-Volum: 0.225 m3

# IfcBuildingElementProxy: ZYR_03.04.03 Fancoil terra:FC03(985), ZYR_03.04.03 Fancoil terra:FC03(985):787090
In: P02 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: FC03(985); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: FC03(985); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.41875 m2; ICAT-Volum: 0.184687 m3

# IfcBuildingElementProxy: ZYR_03.06.01 Ventilador Caixa Aportació:VI02, ZYR_03.06.01 Ventilador Caixa Aportació:VI02:431685
In: PS1 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.10.80 (Uniformat); Group: Mecánica Aire Aportació PK EI 1; Mecánica Aire Aportació PK EI 2
Pset_BuildingElementProxyCommon - Reference: VI02; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: VI02; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 3.80317 m2; ICAT-Volum: 0.376742 m3

# IfcBuildingElementProxy: ZYR_03.06.01 Ventilador Caixa Aportació:VI03, ZYR_03.06.01 Ventilador Caixa Aportació:VI03:802631
In: PsotaC - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.10.80 (Uniformat); Group: ASP 3
Pset_BuildingElementProxyCommon - Reference: VI03; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: VI03; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 4.38225 m2; ICAT-Volum: 0.43965 m3

# IfcBuildingElementProxy: ZYR_03.06.01 Ventilador Caixa Aportació:VI04, ZYR_03.06.01 Ventilador Caixa Aportació:VI04:802418
In: PsotaC - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.10.80 (Uniformat); Group: ASP 4
Pset_BuildingElementProxyCommon - Reference: VI04; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: VI04; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 4.38225 m2; ICAT-Volum: 0.43965 m3

# IfcBuildingElementProxy: ZYR_03.06.01 Ventilador Caixa Extracció:VE01, ZYR_03.06.01 Ventilador Caixa Extracció:VE01:427907
In: PS1 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.10.80 (Uniformat); Group: AEPK 1; AEPK 2
Pset_BuildingElementProxyCommon - Reference: VE01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: VE01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 5.64067 m2; ICAT-Volum: 0.665904 m3

# IfcBuildingElementProxy: ZYR_03.06.01 Ventilador Caixa SobrePressio:VI01, ZYR_03.06.01 Ventilador Caixa SobrePressio:VI01:407786
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.10.80 (Uniformat); Group: ASP 6
Pset_BuildingElementProxyCommon - Reference: VI01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: VI01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.57425 m2; ICAT-Volum: 0.292038 m3

# IfcBuildingElementProxy: ZYR_03.06.02 Recuperador Vertical CR:ZYR_03.06.02 Recuperador Vertical CR, ZYR_03.06.02 Recuperador Vertical CR:ZYR_03.06.02 Recuperador Vertical CR:450455
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.10.90 (Uniformat); Group: AE 1; AI 25; AE 2; AP 1
Pset_BuildingElementProxyCommon - Reference: ZYR_03.06.02 Recuperador Vertical CR; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: ZYR_03.06.02 Recuperador Vertical CR; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 4.41165 m2; ICAT-Volum: 1.19368 m3

# IfcBuildingElementProxy: ZYR_03.06.06 Silenciador Rectangular:SS01, ZYR_03.06.06 Silenciador Rectangular:SS01:434033
In: PS1 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.20.20 (Uniformat); Group: AEPK 2; AEPK 3
Pset_BuildingElementProxyCommon - Reference: SS01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SS01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 3.532 m2; ICAT-Volum: 0.462 m3

# IfcBuildingElementProxy: ZYR_03.06.07 Comporta Talla Foc Rectangular CC:CC02, ZYR_03.06.07 Comporta Talla Foc Rectangular CC:CC02:519173
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.20.30 (Uniformat); Group: Mecánica Aire de retorno 55
Pset_BuildingElementProxyCommon - Reference: CC02; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: CC02; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.749075 m2; ICAT-Volum: 0.04088 m3

# IfcBuildingElementProxy: ZYR_03.06.07 Comporta Talla Foc Rectangular CC:CC03 (2)
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.20.30 (Uniformat); Group: AI 24
Pset_BuildingElementProxyCommon - Reference: CC03; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: CC03; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.3624 m2; ICAT-Volum: 0.112128 m3
Name (ZYR_03.06.07 Comporta Talla Foc Rectangular CC:CC03:...)
768938
771187

# IfcBuildingElementProxy: ZYR_03.06.07 Comporta Talla Foc Rectangular CC:CC04, ZYR_03.06.07 Comporta Talla Foc Rectangular CC:CC04:770917
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.30.20.30 (Uniformat); Group: Mecánica Aire de retorno 32; Mecánica Aire de retorno 44
Pset_BuildingElementProxyCommon - Reference: CC04; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: CC04; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.2614 m2; ICAT-Volum: 0.252288 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:QS-PK, ZYR_05.02.01 Quadre Electric:QS-PK:628711
In: PS1 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: QS-PK; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: QS-PK; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC15, ZYR_05.02.01 Quadre Electric:SC15:561542
In: Nivel 1
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC15; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC15; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC16, ZYR_05.02.01 Quadre Electric:SC16:561541
In: Nivel 1
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC16; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC16; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC17, ZYR_05.02.01 Quadre Electric:SC17:561512
In: P02 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC17; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC17; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC18, ZYR_05.02.01 Quadre Electric:SC18:561511
In: P02 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC18; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC18; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC19, ZYR_05.02.01 Quadre Electric:SC19:561485
In: P03 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC19; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC19; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC20, ZYR_05.02.01 Quadre Electric:SC20:561469
In: P03 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC20; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC20; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC21, ZYR_05.02.01 Quadre Electric:SC21:561443
In: P04 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC21; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC21; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC22, ZYR_05.02.01 Quadre Electric:SC22:561419
In: P04 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC22; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC22; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC23, ZYR_05.02.01 Quadre Electric:SC23:561559
In: P05 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC23; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC23; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC24, ZYR_05.02.01 Quadre Electric:SC24:561558
In: P05 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC24; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC24; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC29, ZYR_05.02.01 Quadre Electric:SC29:700016
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC29; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC29; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC30, ZYR_05.02.01 Quadre Electric:SC30:699986
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC30; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC30; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC33B, ZYR_05.02.01 Quadre Electric:SC33B:700066
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC33B; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC33B; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SC9, ZYR_05.02.01 Quadre Electric:SC9:700030
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SC9; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SC9; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SCS15, ZYR_05.02.01 Quadre Electric:SCS15:561543
In: Nivel 1
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SCS15; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SCS15; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SCS17, ZYR_05.02.01 Quadre Electric:SCS17:561513
In: P02 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SCS17; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SCS17; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SCS19, ZYR_05.02.01 Quadre Electric:SCS19:561493
In: P03 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SCS19; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SCS19; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SCS21, ZYR_05.02.01 Quadre Electric:SCS21:561451
In: P04 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SCS21; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SCS21; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SCS23, ZYR_05.02.01 Quadre Electric:SCS23:561560
In: P05 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SCS23; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SCS23; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SCS30, ZYR_05.02.01 Quadre Electric:SCS30:699993
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SCS30; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SCS30; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.01 Quadre Electric:SCS9, ZYR_05.02.01 Quadre Electric:SCS9:700047
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, GROC
Classification: 50.60.10.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SCS9; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SCS9; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 2.59247 m2; ICAT-Volum: 0.480347 m3

# IfcBuildingElementProxy: ZYR_05.02.02 Presa Doble:01 Toma Doble (38)
Type - Material: Blanco
Classification: 50.60.40.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Toma Doble; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Toma Doble; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0348866 m2; ICAT-Volum: 0.0000851896 m3
Name (ZYR_05.02.02 Presa Doble:01 Toma Doble:...) | In
388273 | P04 - SECTORITZACIÓ I EVACUACIÓ
388287 | P04 - SECTORITZACIÓ I EVACUACIÓ
388495 | P04 - SECTORITZACIÓ I EVACUACIÓ
393894 | P04 - SECTORITZACIÓ I EVACUACIÓ
561597 | P04 - SECTORITZACIÓ I EVACUACIÓ
568507 | P05 - SECTORITZACIÓ I EVACUACIÓ
568525 | P05 - SECTORITZACIÓ I EVACUACIÓ
568526 | P05 - SECTORITZACIÓ I EVACUACIÓ
568527 | P05 - SECTORITZACIÓ I EVACUACIÓ
568529 | P05 - SECTORITZACIÓ I EVACUACIÓ
568531 | P03 - SECTORITZACIÓ I EVACUACIÓ
568532 | P03 - SECTORITZACIÓ I EVACUACIÓ
568533 | P03 - SECTORITZACIÓ I EVACUACIÓ
568535 | P03 - SECTORITZACIÓ I EVACUACIÓ
568537 | P02 - SECTORITZACIÓ I EVACUACIÓ
568538 | P02 - SECTORITZACIÓ I EVACUACIÓ
568539 | P02 - SECTORITZACIÓ I EVACUACIÓ
568541 | P02 - SECTORITZACIÓ I EVACUACIÓ
568545 | Nivel 1
568546 | Nivel 1
568547 | Nivel 1
568549 | Nivel 1
568557 | P03 - SECTORITZACIÓ I EVACUACIÓ
568590 | P02 - SECTORITZACIÓ I EVACUACIÓ
682031 | P0A - SECTORITZACIÓ I EVACUACIÓ
682076 | P0A - SECTORITZACIÓ I EVACUACIÓ
682093 | P0A - SECTORITZACIÓ I EVACUACIÓ
682094 | P0A - SECTORITZACIÓ I EVACUACIÓ
682146 | P0A - SECTORITZACIÓ I EVACUACIÓ
683742 | P00 - SECTORITZACIÓ I EVACUACIÓ
683743 | P00 - SECTORITZACIÓ I EVACUACIÓ
683838 | P0A - SECTORITZACIÓ I EVACUACIÓ
683840 | P0A - SECTORITZACIÓ I EVACUACIÓ
683852 | P00 - SECTORITZACIÓ I EVACUACIÓ
683902 | P00 - SECTORITZACIÓ I EVACUACIÓ
699520 | P00 - SECTORITZACIÓ I EVACUACIÓ
699601 | P0A - SECTORITZACIÓ I EVACUACIÓ
699637 | P0A - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_05.02.02 Presa Doble:05 Toma Doble Estanca, ZYR_05.02.02 Presa Doble:05 Toma Doble Estanca:699419
In: PS1 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: Blanco
Classification: 50.60.40.10 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 05 Toma Doble Estanca; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 05 Toma Doble Estanca; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0381906 m2; ICAT-Volum: 0.000260438 m3

# IfcBuildingElementProxy: ZYR_05.02.02 Presa Simple Paret 2:01 Presa Previsio (4)
Type - Material: <Unnamed>
Classification: 50.60.40.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Presa Previsio; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Presa Previsio; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0146788 m2; ICAT-Volum: 0.0000499544 m3
Name (ZYR_05.02.02 Presa Simple Paret 2:01 Presa Previsio:...) | In
568203 | P04 - SECTORITZACIÓ I EVACUACIÓ
568510 | P05 - SECTORITZACIÓ I EVACUACIÓ
568560 | P03 - SECTORITZACIÓ I EVACUACIÓ
568593 | P02 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_05.02.02 Presa Simple Paret:01 Presa SIMPLE (7)
Type - Material: Blanco
Classification: 50.60.40.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Presa SIMPLE; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Presa SIMPLE; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0210214 m2; ICAT-Volum: 0.0000499544 m3
Name (ZYR_05.02.02 Presa Simple Paret:01 Presa SIMPLE:...) | In
393774 | P04 - SECTORITZACIÓ I EVACUACIÓ
568528 | P05 - SECTORITZACIÓ I EVACUACIÓ
568534 | P03 - SECTORITZACIÓ I EVACUACIÓ
568540 | P02 - SECTORITZACIÓ I EVACUACIÓ
568548 | Nivel 1
683839 | P0A - SECTORITZACIÓ I EVACUACIÓ
683853 | P00 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_05.02.02 Presa Terra:03 Presa Previsió (4)
Type - Material: <Unnamed>
Classification: 50.60.40.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 03 Presa Previsió; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 03 Presa Previsió; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0149284 m2; ICAT-Volum: 0.0000560473 m3
Name (ZYR_05.02.02 Presa Terra:03 Presa Previsió:...) | In
801103 | P02 - SECTORITZACIÓ I EVACUACIÓ
801172 | P03 - SECTORITZACIÓ I EVACUACIÓ
801228 | P04 - SECTORITZACIÓ I EVACUACIÓ
801278 | P05 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_05.02.05 PT 4COL Terra:07 PT Terra (4SC-2SAI-2VD) (230)
Type - Material: Plastico Gris
Classification: 50.60.40.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 07 PT Terra (4SC-2SAI-2VD); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 07 PT Terra (4SC-2SAI-2VD); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0439209 m2; ICAT-Volum: 0.000220322 m3
Name (ZYR_05.02.05 PT 4COL Terra:07 PT Terra (4SC-2SAI-2VD):...) | In
378518 | P04 - SECTORITZACIÓ I EVACUACIÓ
379085 | P03 - SECTORITZACIÓ I EVACUACIÓ
379086 | P03 - SECTORITZACIÓ I EVACUACIÓ
379109 | P03 - SECTORITZACIÓ I EVACUACIÓ
379117 | P03 - SECTORITZACIÓ I EVACUACIÓ
379125 | P03 - SECTORITZACIÓ I EVACUACIÓ
379133 | P03 - SECTORITZACIÓ I EVACUACIÓ
379261 | P03 - SECTORITZACIÓ I EVACUACIÓ
379412 | P02 - SECTORITZACIÓ I EVACUACIÓ
379489 | P02 - SECTORITZACIÓ I EVACUACIÓ
379603 | P02 - SECTORITZACIÓ I EVACUACIÓ
379659 | P02 - SECTORITZACIÓ I EVACUACIÓ
379667 | P02 - SECTORITZACIÓ I EVACUACIÓ
379675 | P02 - SECTORITZACIÓ I EVACUACIÓ
379685 | P02 - SECTORITZACIÓ I EVACUACIÓ
379731 | P02 - SECTORITZACIÓ I EVACUACIÓ
379739 | P02 - SECTORITZACIÓ I EVACUACIÓ
379749 | P02 - SECTORITZACIÓ I EVACUACIÓ
379759 | P02 - SECTORITZACIÓ I EVACUACIÓ
379767 | P02 - SECTORITZACIÓ I EVACUACIÓ
379801 | P02 - SECTORITZACIÓ I EVACUACIÓ
379974 | Nivel 1
379980 | Nivel 1
379988 | Nivel 1
380002 | Nivel 1
380008 | Nivel 1
380020 | Nivel 1
380030 | Nivel 1
380040 | Nivel 1
380050 | Nivel 1
380058 | Nivel 1
380068 | Nivel 1
380076 | Nivel 1
380084 | Nivel 1
380092 | Nivel 1
380100 | Nivel 1
380156 | Nivel 1
380164 | Nivel 1
380174 | Nivel 1
380182 | Nivel 1
380194 | Nivel 1
380202 | Nivel 1
380273 | Nivel 1
380281 | Nivel 1
380289 | Nivel 1
381355 | P05 - SECTORITZACIÓ I EVACUACIÓ
381459 | P03 - SECTORITZACIÓ I EVACUACIÓ
381534 | P03 - SECTORITZACIÓ I EVACUACIÓ
381635 | P03 - SECTORITZACIÓ I EVACUACIÓ
381643 | P03 - SECTORITZACIÓ I EVACUACIÓ
381787 | P02 - SECTORITZACIÓ I EVACUACIÓ
381797 | P02 - SECTORITZACIÓ I EVACUACIÓ
381910 | P03 - SECTORITZACIÓ I EVACUACIÓ
421340 | P05 - SECTORITZACIÓ I EVACUACIÓ
422577 | P02 - SECTORITZACIÓ I EVACUACIÓ
607253 | Nivel 1
607254 | Nivel 1
607255 | Nivel 1
607299 | Nivel 1
607300 | Nivel 1
607301 | Nivel 1
607302 | Nivel 1
607303 | Nivel 1
607304 | Nivel 1
607515 | P02 - SECTORITZACIÓ I EVACUACIÓ
607592 | Nivel 1
607593 | Nivel 1
607594 | Nivel 1
607595 | Nivel 1
607879 | Nivel 1
607880 | Nivel 1
607964 | P02 - SECTORITZACIÓ I EVACUACIÓ
607965 | P02 - SECTORITZACIÓ I EVACUACIÓ
608131 | P02 - SECTORITZACIÓ I EVACUACIÓ
608132 | P02 - SECTORITZACIÓ I EVACUACIÓ
608152 | P02 - SECTORITZACIÓ I EVACUACIÓ
608153 | P02 - SECTORITZACIÓ I EVACUACIÓ
608321 | P02 - SECTORITZACIÓ I EVACUACIÓ
608322 | P02 - SECTORITZACIÓ I EVACUACIÓ
608375 | P02 - SECTORITZACIÓ I EVACUACIÓ
608376 | P02 - SECTORITZACIÓ I EVACUACIÓ
608377 | P02 - SECTORITZACIÓ I EVACUACIÓ
608378 | P02 - SECTORITZACIÓ I EVACUACIÓ
608781 | P02 - SECTORITZACIÓ I EVACUACIÓ
608782 | P02 - SECTORITZACIÓ I EVACUACIÓ
608783 | P02 - SECTORITZACIÓ I EVACUACIÓ
608784 | P02 - SECTORITZACIÓ I EVACUACIÓ
608813 | P02 - SECTORITZACIÓ I EVACUACIÓ
608814 | P02 - SECTORITZACIÓ I EVACUACIÓ
608815 | P02 - SECTORITZACIÓ I EVACUACIÓ
608816 | P02 - SECTORITZACIÓ I EVACUACIÓ
608817 | P02 - SECTORITZACIÓ I EVACUACIÓ
608818 | P02 - SECTORITZACIÓ I EVACUACIÓ
608986 | P02 - SECTORITZACIÓ I EVACUACIÓ
608987 | P02 - SECTORITZACIÓ I EVACUACIÓ
608988 | P02 - SECTORITZACIÓ I EVACUACIÓ
608989 | P02 - SECTORITZACIÓ I EVACUACIÓ
608990 | P02 - SECTORITZACIÓ I EVACUACIÓ
608991 | P02 - SECTORITZACIÓ I EVACUACIÓ
609120 | P03 - SECTORITZACIÓ I EVACUACIÓ
609121 | P03 - SECTORITZACIÓ I EVACUACIÓ
609141 | P03 - SECTORITZACIÓ I EVACUACIÓ
609142 | P03 - SECTORITZACIÓ I EVACUACIÓ
609373 | P03 - SECTORITZACIÓ I EVACUACIÓ
609374 | P03 - SECTORITZACIÓ I EVACUACIÓ
609375 | P03 - SECTORITZACIÓ I EVACUACIÓ
609376 | P03 - SECTORITZACIÓ I EVACUACIÓ
609436 | P03 - SECTORITZACIÓ I EVACUACIÓ
609437 | P03 - SECTORITZACIÓ I EVACUACIÓ
609438 | P03 - SECTORITZACIÓ I EVACUACIÓ
609439 | P03 - SECTORITZACIÓ I EVACUACIÓ
609449 | P03 - SECTORITZACIÓ I EVACUACIÓ
609450 | P03 - SECTORITZACIÓ I EVACUACIÓ
609451 | P03 - SECTORITZACIÓ I EVACUACIÓ
609452 | P03 - SECTORITZACIÓ I EVACUACIÓ
609464 | P03 - SECTORITZACIÓ I EVACUACIÓ
609465 | P03 - SECTORITZACIÓ I EVACUACIÓ
609466 | P03 - SECTORITZACIÓ I EVACUACIÓ
609467 | P03 - SECTORITZACIÓ I EVACUACIÓ
609477 | P03 - SECTORITZACIÓ I EVACUACIÓ
609478 | P03 - SECTORITZACIÓ I EVACUACIÓ
609479 | P03 - SECTORITZACIÓ I EVACUACIÓ
609480 | P03 - SECTORITZACIÓ I EVACUACIÓ
609504 | P03 - SECTORITZACIÓ I EVACUACIÓ
609505 | P03 - SECTORITZACIÓ I EVACUACIÓ
609558 | P04 - SECTORITZACIÓ I EVACUACIÓ
609559 | P04 - SECTORITZACIÓ I EVACUACIÓ
609560 | P04 - SECTORITZACIÓ I EVACUACIÓ
609561 | P04 - SECTORITZACIÓ I EVACUACIÓ
609615 | P04 - SECTORITZACIÓ I EVACUACIÓ
609616 | P04 - SECTORITZACIÓ I EVACUACIÓ
609617 | P04 - SECTORITZACIÓ I EVACUACIÓ
609618 | P04 - SECTORITZACIÓ I EVACUACIÓ
609632 | P04 - SECTORITZACIÓ I EVACUACIÓ
609633 | P04 - SECTORITZACIÓ I EVACUACIÓ
609634 | P04 - SECTORITZACIÓ I EVACUACIÓ
609635 | P04 - SECTORITZACIÓ I EVACUACIÓ
609649 | P04 - SECTORITZACIÓ I EVACUACIÓ
609650 | P04 - SECTORITZACIÓ I EVACUACIÓ
609651 | P04 - SECTORITZACIÓ I EVACUACIÓ
609652 | P04 - SECTORITZACIÓ I EVACUACIÓ
609660 | P04 - SECTORITZACIÓ I EVACUACIÓ
609661 | P04 - SECTORITZACIÓ I EVACUACIÓ
609662 | P04 - SECTORITZACIÓ I EVACUACIÓ
609663 | P04 - SECTORITZACIÓ I EVACUACIÓ
609733 | P04 - SECTORITZACIÓ I EVACUACIÓ
609734 | P04 - SECTORITZACIÓ I EVACUACIÓ
609735 | P04 - SECTORITZACIÓ I EVACUACIÓ
609736 | P04 - SECTORITZACIÓ I EVACUACIÓ
609737 | P04 - SECTORITZACIÓ I EVACUACIÓ
609738 | P04 - SECTORITZACIÓ I EVACUACIÓ
609874 | P04 - SECTORITZACIÓ I EVACUACIÓ
609875 | P04 - SECTORITZACIÓ I EVACUACIÓ
609876 | P04 - SECTORITZACIÓ I EVACUACIÓ
609877 | P04 - SECTORITZACIÓ I EVACUACIÓ
609878 | P04 - SECTORITZACIÓ I EVACUACIÓ
609879 | P04 - SECTORITZACIÓ I EVACUACIÓ
609889 | P04 - SECTORITZACIÓ I EVACUACIÓ
609890 | P04 - SECTORITZACIÓ I EVACUACIÓ
609891 | P04 - SECTORITZACIÓ I EVACUACIÓ
609892 | P04 - SECTORITZACIÓ I EVACUACIÓ
609893 | P04 - SECTORITZACIÓ I EVACUACIÓ
609894 | P04 - SECTORITZACIÓ I EVACUACIÓ
609904 | P04 - SECTORITZACIÓ I EVACUACIÓ
609905 | P04 - SECTORITZACIÓ I EVACUACIÓ
609906 | P04 - SECTORITZACIÓ I EVACUACIÓ
609907 | P04 - SECTORITZACIÓ I EVACUACIÓ
609908 | P04 - SECTORITZACIÓ I EVACUACIÓ
609909 | P04 - SECTORITZACIÓ I EVACUACIÓ
609939 | P05 - SECTORITZACIÓ I EVACUACIÓ
609940 | P05 - SECTORITZACIÓ I EVACUACIÓ
609941 | P05 - SECTORITZACIÓ I EVACUACIÓ
609942 | P05 - SECTORITZACIÓ I EVACUACIÓ
609943 | P05 - SECTORITZACIÓ I EVACUACIÓ
609944 | P05 - SECTORITZACIÓ I EVACUACIÓ
610229 | P05 - SECTORITZACIÓ I EVACUACIÓ
610230 | P05 - SECTORITZACIÓ I EVACUACIÓ
610231 | P05 - SECTORITZACIÓ I EVACUACIÓ
610232 | P05 - SECTORITZACIÓ I EVACUACIÓ
610233 | P05 - SECTORITZACIÓ I EVACUACIÓ
610234 | P05 - SECTORITZACIÓ I EVACUACIÓ
610244 | P05 - SECTORITZACIÓ I EVACUACIÓ
610245 | P05 - SECTORITZACIÓ I EVACUACIÓ
610246 | P05 - SECTORITZACIÓ I EVACUACIÓ
610247 | P05 - SECTORITZACIÓ I EVACUACIÓ
610248 | P05 - SECTORITZACIÓ I EVACUACIÓ
610249 | P05 - SECTORITZACIÓ I EVACUACIÓ
610286 | P05 - SECTORITZACIÓ I EVACUACIÓ
610287 | P05 - SECTORITZACIÓ I EVACUACIÓ
610288 | P05 - SECTORITZACIÓ I EVACUACIÓ
610289 | P05 - SECTORITZACIÓ I EVACUACIÓ
610375 | P05 - SECTORITZACIÓ I EVACUACIÓ
610376 | P05 - SECTORITZACIÓ I EVACUACIÓ
610377 | P05 - SECTORITZACIÓ I EVACUACIÓ
610378 | P05 - SECTORITZACIÓ I EVACUACIÓ
610386 | P05 - SECTORITZACIÓ I EVACUACIÓ
610387 | P05 - SECTORITZACIÓ I EVACUACIÓ
610388 | P05 - SECTORITZACIÓ I EVACUACIÓ
610389 | P05 - SECTORITZACIÓ I EVACUACIÓ
610401 | P05 - SECTORITZACIÓ I EVACUACIÓ
610402 | P05 - SECTORITZACIÓ I EVACUACIÓ
610403 | P05 - SECTORITZACIÓ I EVACUACIÓ
610404 | P05 - SECTORITZACIÓ I EVACUACIÓ
610412 | P05 - SECTORITZACIÓ I EVACUACIÓ
610413 | P05 - SECTORITZACIÓ I EVACUACIÓ
610414 | P05 - SECTORITZACIÓ I EVACUACIÓ
610415 | P05 - SECTORITZACIÓ I EVACUACIÓ
610423 | P05 - SECTORITZACIÓ I EVACUACIÓ
610424 | P05 - SECTORITZACIÓ I EVACUACIÓ
610425 | P05 - SECTORITZACIÓ I EVACUACIÓ
610426 | P05 - SECTORITZACIÓ I EVACUACIÓ
610436 | P05 - SECTORITZACIÓ I EVACUACIÓ
610437 | P05 - SECTORITZACIÓ I EVACUACIÓ
610438 | P05 - SECTORITZACIÓ I EVACUACIÓ
610439 | P05 - SECTORITZACIÓ I EVACUACIÓ
610447 | P05 - SECTORITZACIÓ I EVACUACIÓ
610448 | P05 - SECTORITZACIÓ I EVACUACIÓ
610449 | P05 - SECTORITZACIÓ I EVACUACIÓ
610450 | P05 - SECTORITZACIÓ I EVACUACIÓ
610462 | P05 - SECTORITZACIÓ I EVACUACIÓ
610463 | P05 - SECTORITZACIÓ I EVACUACIÓ
610464 | P05 - SECTORITZACIÓ I EVACUACIÓ
610465 | P05 - SECTORITZACIÓ I EVACUACIÓ
610544 | P05 - SECTORITZACIÓ I EVACUACIÓ
682211 | P00 - SECTORITZACIÓ I EVACUACIÓ
682268 | P00 - SECTORITZACIÓ I EVACUACIÓ
682276 | P00 - SECTORITZACIÓ I EVACUACIÓ
682286 | P00 - SECTORITZACIÓ I EVACUACIÓ
682587 | P00 - SECTORITZACIÓ I EVACUACIÓ
682619 | P00 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_05.02.05 PT 4COL Terra:08 PT Terra (2SC-4SAI-2VD) (4)
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: Plastico Gris
Classification: 50.60.40.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 08 PT Terra (2SC-4SAI-2VD); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 08 PT Terra (2SC-4SAI-2VD); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0439209 m2; ICAT-Volum: 0.000220322 m3
Name (ZYR_05.02.05 PT 4COL Terra:08 PT Terra (2SC-4SAI-2VD):...)
651882
681736
681868
681888

# IfcBuildingElementProxy: ZYR_05.02.05 PT 4COL Terra:14 PT Terra (2SC-4SAI-2VD) (6)
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: Plastico Gris
Classification: 50.60.40.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 14 PT Terra (2SC-4SAI-2VD); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 14 PT Terra (2SC-4SAI-2VD); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0439209 m2; ICAT-Volum: 0.000220322 m3
Name (ZYR_05.02.05 PT 4COL Terra:14 PT Terra (2SC-4SAI-2VD):...)
651565
651604
651708
651756
651805
651971

# IfcBuildingElementProxy: ZYR_05.02.05 PT 4COL Terra:4SC+ 2SAI+2VD (8)
Type - Material: Plastico Gris
Classification: 50.60.40.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 4SC+ 2SAI+2VD; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 4SC+ 2SAI+2VD; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0439209 m2; ICAT-Volum: 0.000220322 m3
Name (ZYR_05.02.05 PT 4COL Terra:4SC+ 2SAI+2VD:...) | In
378691 | P04 - SECTORITZACIÓ I EVACUACIÓ
379285 | P02 - SECTORITZACIÓ I EVACUACIÓ
381321 | P05 - SECTORITZACIÓ I EVACUACIÓ
381542 | P03 - SECTORITZACIÓ I EVACUACIÓ
381586 | P03 - SECTORITZACIÓ I EVACUACIÓ
381843 | P02 - SECTORITZACIÓ I EVACUACIÓ
421568 | P05 - SECTORITZACIÓ I EVACUACIÓ
421646 | P04 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_06.01 Detector Presència Paret:Detector 90º (26)
Type - Material: <Unnamed>, Vidrio
Classification: 50.60.50.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Detector 90º; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Detector 90º; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0857513 m2; ICAT-Volum: 0.00287808 m3
Name (ZYR_06.01 Detector Presència Paret:Detector 90º:...) | In
578919 | Nivel 1
595425 | Nivel 1
595436 | Nivel 1
595551 | P02 - SECTORITZACIÓ I EVACUACIÓ
595556 | P02 - SECTORITZACIÓ I EVACUACIÓ
595557 | P02 - SECTORITZACIÓ I EVACUACIÓ
596324 | P03 - SECTORITZACIÓ I EVACUACIÓ
596329 | P03 - SECTORITZACIÓ I EVACUACIÓ
596330 | P03 - SECTORITZACIÓ I EVACUACIÓ
596855 | P04 - SECTORITZACIÓ I EVACUACIÓ
596860 | P04 - SECTORITZACIÓ I EVACUACIÓ
596861 | P04 - SECTORITZACIÓ I EVACUACIÓ
597131 | P05 - SECTORITZACIÓ I EVACUACIÓ
597136 | P05 - SECTORITZACIÓ I EVACUACIÓ
597137 | P05 - SECTORITZACIÓ I EVACUACIÓ
597460 | P0A - SECTORITZACIÓ I EVACUACIÓ
597461 | P0A - SECTORITZACIÓ I EVACUACIÓ
597463 | P0A - SECTORITZACIÓ I EVACUACIÓ
597464 | P0A - SECTORITZACIÓ I EVACUACIÓ
597500 | P0A - SECTORITZACIÓ I EVACUACIÓ
659621 | P00 - SECTORITZACIÓ I EVACUACIÓ
659626 | P00 - SECTORITZACIÓ I EVACUACIÓ
659627 | P00 - SECTORITZACIÓ I EVACUACIÓ
679178 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679624 | P00 - SECTORITZACIÓ I EVACUACIÓ
701481 | P00 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_06.01 Detector Sostre:01 Detector Presencia 360º (39)
Type - Material: Color Blanco, Color Cristal
Type - Pset_ManufacturerTypeInformation - Manufacturer: 50.60.50.20
Pset_BuildingElementProxyCommon - Reference: 01 Detector Presencia 360º; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Detector Presencia 360º; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0210354 m2; ICAT-Volum: 0.00032729 m3
Name (ZYR_06.01 Detector Sostre:01 Detector Presencia 360º:...) | In
595323 | Nivel 1
595359 | Nivel 1
595376 | Nivel 1
595390 | Nivel 1
595552 | P02 - SECTORITZACIÓ I EVACUACIÓ
595553 | P02 - SECTORITZACIÓ I EVACUACIÓ
595554 | P02 - SECTORITZACIÓ I EVACUACIÓ
595555 | P02 - SECTORITZACIÓ I EVACUACIÓ
596325 | P03 - SECTORITZACIÓ I EVACUACIÓ
596326 | P03 - SECTORITZACIÓ I EVACUACIÓ
596327 | P03 - SECTORITZACIÓ I EVACUACIÓ
596328 | P03 - SECTORITZACIÓ I EVACUACIÓ
596856 | P04 - SECTORITZACIÓ I EVACUACIÓ
596857 | P04 - SECTORITZACIÓ I EVACUACIÓ
596858 | P04 - SECTORITZACIÓ I EVACUACIÓ
596859 | P04 - SECTORITZACIÓ I EVACUACIÓ
597132 | P05 - SECTORITZACIÓ I EVACUACIÓ
597133 | P05 - SECTORITZACIÓ I EVACUACIÓ
597134 | P05 - SECTORITZACIÓ I EVACUACIÓ
597135 | P05 - SECTORITZACIÓ I EVACUACIÓ
597433 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
597451 | P0A - SECTORITZACIÓ I EVACUACIÓ
597472 | P0A - SECTORITZACIÓ I EVACUACIÓ
597480 | P0A - SECTORITZACIÓ I EVACUACIÓ
597514 | P0A - SECTORITZACIÓ I EVACUACIÓ
597522 | P0A - SECTORITZACIÓ I EVACUACIÓ
659622 | P00 - SECTORITZACIÓ I EVACUACIÓ
659623 | P00 - SECTORITZACIÓ I EVACUACIÓ
659624 | P00 - SECTORITZACIÓ I EVACUACIÓ
659625 | P00 - SECTORITZACIÓ I EVACUACIÓ
678608 | PS1 - SECTORITZACIÓ I EVACUACIÓ
678621 | PS1 - SECTORITZACIÓ I EVACUACIÓ
678627 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679179 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679515 | P00 - SECTORITZACIÓ I EVACUACIÓ
679788 | P00 - SECTORITZACIÓ I EVACUACIÓ
679808 | P00 - SECTORITZACIÓ I EVACUACIÓ
701289 | PS1 - SECTORITZACIÓ I EVACUACIÓ
701923 | P0A - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_06.01 Detector Sostre:06 Detector Presencia Generic 04, ZYR_06.01 Detector Sostre:06 Detector Presencia Generic 04:753402
In: Nivel 1
Type - Material: Color Blanco, Color Cristal
Type - Pset_ManufacturerTypeInformation - Manufacturer: 50.60.50.20
Pset_BuildingElementProxyCommon - Reference: 06 Detector Presencia Generic 04; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 06 Detector Presencia Generic 04; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0210354 m2; ICAT-Volum: 0.00032729 m3

# IfcBuildingElementProxy: ZYR_06.01 Detector Sostre:07 Detector Luminic (35)
Type - Material: Color Blanco, Color Cristal
Type - Pset_ManufacturerTypeInformation - Manufacturer: 50.60.50.20
Pset_BuildingElementProxyCommon - Reference: 07 Detector Luminic; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 07 Detector Luminic; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0210354 m2; ICAT-Volum: 0.00032729 m3
Name (ZYR_06.01 Detector Sostre:07 Detector Luminic:...) | In
595452 | Nivel 1
595478 | Nivel 1
595519 | Nivel 1
595539 | Nivel 1
596208 | P02 - SECTORITZACIÓ I EVACUACIÓ
596222 | P02 - SECTORITZACIÓ I EVACUACIÓ
596340 | P02 - SECTORITZACIÓ I EVACUACIÓ
596350 | P03 - SECTORITZACIÓ I EVACUACIÓ
596425 | P03 - SECTORITZACIÓ I EVACUACIÓ
596433 | P03 - SECTORITZACIÓ I EVACUACIÓ
596455 | P03 - SECTORITZACIÓ I EVACUACIÓ
596724 | P03 - SECTORITZACIÓ I EVACUACIÓ
596732 | P03 - SECTORITZACIÓ I EVACUACIÓ
596740 | P03 - SECTORITZACIÓ I EVACUACIÓ
596841 | P03 - SECTORITZACIÓ I EVACUACIÓ
596882 | P04 - SECTORITZACIÓ I EVACUACIÓ
597107 | P04 - SECTORITZACIÓ I EVACUACIÓ
597119 | P04 - SECTORITZACIÓ I EVACUACIÓ
597143 | P05 - SECTORITZACIÓ I EVACUACIÓ
597175 | P05 - SECTORITZACIÓ I EVACUACIÓ
597183 | P05 - SECTORITZACIÓ I EVACUACIÓ
597199 | P05 - SECTORITZACIÓ I EVACUACIÓ
651351 | Nivel 1
651371 | Nivel 1
651391 | P02 - SECTORITZACIÓ I EVACUACIÓ
651441 | P02 - SECTORITZACIÓ I EVACUACIÓ
651481 | P02 - SECTORITZACIÓ I EVACUACIÓ
651503 | P04 - SECTORITZACIÓ I EVACUACIÓ
651519 | P05 - SECTORITZACIÓ I EVACUACIÓ
651539 | P05 - SECTORITZACIÓ I EVACUACIÓ
651555 | P05 - SECTORITZACIÓ I EVACUACIÓ
682690 | P04 - SECTORITZACIÓ I EVACUACIÓ
682704 | P04 - SECTORITZACIÓ I EVACUACIÓ
683106 | P03 - SECTORITZACIÓ I EVACUACIÓ
683471 | Nivel 1

# IfcBuildingElementProxy: ZYR_06.01 Mecanismes Doble:01 Interruptor Doble (17)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Interruptor Doble; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Interruptor Doble; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0151085 m2; ICAT-Volum: 0.0000552811 m3
Name (ZYR_06.01 Mecanismes Doble:01 Interruptor Doble:...) | In
583138 | Nivel 1
583268 | Nivel 1
590984 | Nivel 1
595604 | P02 - SECTORITZACIÓ I EVACUACIÓ
595617 | P02 - SECTORITZACIÓ I EVACUACIÓ
595667 | P02 - SECTORITZACIÓ I EVACUACIÓ
595716 | P02 - SECTORITZACIÓ I EVACUACIÓ
596143 | P02 - SECTORITZACIÓ I EVACUACIÓ
596348 | P03 - SECTORITZACIÓ I EVACUACIÓ
596473 | P03 - SECTORITZACIÓ I EVACUACIÓ
596519 | P03 - SECTORITZACIÓ I EVACUACIÓ
596762 | P03 - SECTORITZACIÓ I EVACUACIÓ
596790 | P03 - SECTORITZACIÓ I EVACUACIÓ
596824 | P03 - SECTORITZACIÓ I EVACUACIÓ
596865 | P04 - SECTORITZACIÓ I EVACUACIÓ
597138 | P05 - SECTORITZACIÓ I EVACUACIÓ
701809 | P0A - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_06.01 Mecanismes Doble:03 Conmutador Doble (21)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 03 Conmutador Doble; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 03 Conmutador Doble; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0151085 m2; ICAT-Volum: 0.0000552811 m3
Name (ZYR_06.01 Mecanismes Doble:03 Conmutador Doble:...) | In
583223 | Nivel 1
583231 | Nivel 1
591134 | Nivel 1
591183 | Nivel 1
595561 | P02 - SECTORITZACIÓ I EVACUACIÓ
595562 | P02 - SECTORITZACIÓ I EVACUACIÓ
595755 | P02 - SECTORITZACIÓ I EVACUACIÓ
595998 | P02 - SECTORITZACIÓ I EVACUACIÓ
596032 | P02 - SECTORITZACIÓ I EVACUACIÓ
596583 | P03 - SECTORITZACIÓ I EVACUACIÓ
596584 | P03 - SECTORITZACIÓ I EVACUACIÓ
596899 | P04 - SECTORITZACIÓ I EVACUACIÓ
596927 | P04 - SECTORITZACIÓ I EVACUACIÓ
596999 | P04 - SECTORITZACIÓ I EVACUACIÓ
597000 | P04 - SECTORITZACIÓ I EVACUACIÓ
597139 | P05 - SECTORITZACIÓ I EVACUACIÓ
597140 | P05 - SECTORITZACIÓ I EVACUACIÓ
597141 | P05 - SECTORITZACIÓ I EVACUACIÓ
597142 | P05 - SECTORITZACIÓ I EVACUACIÓ
597218 | P05 - SECTORITZACIÓ I EVACUACIÓ
597249 | P05 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_06.01 Mecanismes:01 Interruptor (42)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Interruptor; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Interruptor; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0142595 m2; ICAT-Volum: 0.0000634475 m3
Name (ZYR_06.01 Mecanismes:01 Interruptor:...) | In
590589 | Nivel 1
590732 | Nivel 1
590807 | Nivel 1
590815 | Nivel 1
590823 | Nivel 1
590835 | Nivel 1
590904 | Nivel 1
590914 | Nivel 1
590924 | Nivel 1
590934 | Nivel 1
590966 | Nivel 1
590985 | Nivel 1
591024 | Nivel 1
591066 | Nivel 1
595605 | P02 - SECTORITZACIÓ I EVACUACIÓ
595862 | P02 - SECTORITZACIÓ I EVACUACIÓ
596144 | P02 - SECTORITZACIÓ I EVACUACIÓ
596245 | P02 - SECTORITZACIÓ I EVACUACIÓ
596273 | P02 - SECTORITZACIÓ I EVACUACIÓ
596312 | P02 - SECTORITZACIÓ I EVACUACIÓ
596349 | P03 - SECTORITZACIÓ I EVACUACIÓ
596555 | P03 - SECTORITZACIÓ I EVACUACIÓ
596565 | P03 - SECTORITZACIÓ I EVACUACIÓ
596763 | P03 - SECTORITZACIÓ I EVACUACIÓ
596791 | P03 - SECTORITZACIÓ I EVACUACIÓ
596825 | P03 - SECTORITZACIÓ I EVACUACIÓ
597031 | P04 - SECTORITZACIÓ I EVACUACIÓ
597081 | P04 - SECTORITZACIÓ I EVACUACIÓ
597089 | P04 - SECTORITZACIÓ I EVACUACIÓ
597284 | P05 - SECTORITZACIÓ I EVACUACIÓ
597319 | P05 - SECTORITZACIÓ I EVACUACIÓ
679647 | P00 - SECTORITZACIÓ I EVACUACIÓ
679705 | P00 - SECTORITZACIÓ I EVACUACIÓ
679868 | P00 - SECTORITZACIÓ I EVACUACIÓ
679876 | P00 - SECTORITZACIÓ I EVACUACIÓ
679909 | P00 - SECTORITZACIÓ I EVACUACIÓ
680618 | P0A - SECTORITZACIÓ I EVACUACIÓ
680651 | P0A - SECTORITZACIÓ I EVACUACIÓ
680659 | P0A - SECTORITZACIÓ I EVACUACIÓ
680747 | P0A - SECTORITZACIÓ I EVACUACIÓ
701594 | P0A - SECTORITZACIÓ I EVACUACIÓ
701619 | P0A - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_06.01 Mecanismes:02 Commutador (4)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 02 Commutador; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 02 Commutador; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0142595 m2; ICAT-Volum: 0.0000634475 m3
Name (ZYR_06.01 Mecanismes:02 Commutador:...) | In
596596 | P03 - SECTORITZACIÓ I EVACUACIÓ
597370 | P05 - SECTORITZACIÓ I EVACUACIÓ
597415 | P05 - SECTORITZACIÓ I EVACUACIÓ
682822 | P03 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_06.03 Emer Paret Rect:02 Emergencia Pared Superficie 02 (14)
Type - Material: <Unnamed>, Vidrio
Classification: 50.60.50.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 02 Emergencia Pared Superficie 02; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 02 Emergencia Pared Superficie 02; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.052595 m2; ICAT-Volum: 0.0008604 m3
Name (ZYR_06.03 Emer Paret Rect:02 Emergencia Pared Superficie 02:...) | In
554899 | P0A - SECTORITZACIÓ I EVACUACIÓ
555123 | P0A - SECTORITZACIÓ I EVACUACIÓ
555147 | Nivel 1
555148 | Nivel 1
555150 | P02 - SECTORITZACIÓ I EVACUACIÓ
555151 | P02 - SECTORITZACIÓ I EVACUACIÓ
555153 | P03 - SECTORITZACIÓ I EVACUACIÓ
555154 | P03 - SECTORITZACIÓ I EVACUACIÓ
555156 | P04 - SECTORITZACIÓ I EVACUACIÓ
555157 | P04 - SECTORITZACIÓ I EVACUACIÓ
555164 | P05 - SECTORITZACIÓ I EVACUACIÓ
555165 | P05 - SECTORITZACIÓ I EVACUACIÓ
555171 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
559581 | P0A - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_06.03 Emer Paret Rect:06 Emergencia Pared Estanca 01 (4)
Type - Material: <Unnamed>, Vidrio
Classification: 50.60.50.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 06 Emergencia Pared Estanca 01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 06 Emergencia Pared Estanca 01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.052595 m2; ICAT-Volum: 0.0008604 m3
Name (ZYR_06.03 Emer Paret Rect:06 Emergencia Pared Estanca 01:...) | In
553165 | PS2 - SECTORITZACIÓ I EVACUACIÓ
554031 | PS1 - SECTORITZACIÓ I EVACUACIÓ
555073 | P00 - SECTORITZACIÓ I EVACUACIÓ
555088 | P00 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_06.03 Emer Sostre Rect:01 Emergencia Superficie 01 (153)
Type - Material: <Unnamed>, Vidrio
Classification: 50.60.50.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 01 Emergencia Superficie 01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 01 Emergencia Superficie 01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.052595 m2; ICAT-Volum: 0.0008604 m3
Name (ZYR_06.03 Emer Sostre Rect:01 Emergencia Superficie 01:...) | In
554044 | P00 - SECTORITZACIÓ I EVACUACIÓ
554063 | P00 - SECTORITZACIÓ I EVACUACIÓ
554109 | P00 - SECTORITZACIÓ I EVACUACIÓ
554350 | P00 - SECTORITZACIÓ I EVACUACIÓ
554388 | P00 - SECTORITZACIÓ I EVACUACIÓ
554398 | P00 - SECTORITZACIÓ I EVACUACIÓ
554416 | P00 - SECTORITZACIÓ I EVACUACIÓ
554434 | P00 - SECTORITZACIÓ I EVACUACIÓ
554448 | P00 - SECTORITZACIÓ I EVACUACIÓ
554597 | P00 - SECTORITZACIÓ I EVACUACIÓ
555333 | P0A - SECTORITZACIÓ I EVACUACIÓ
555359 | P0A - SECTORITZACIÓ I EVACUACIÓ
555519 | P0A - SECTORITZACIÓ I EVACUACIÓ
555575 | P0A - SECTORITZACIÓ I EVACUACIÓ
555653 | P0A - SECTORITZACIÓ I EVACUACIÓ
555661 | P0A - SECTORITZACIÓ I EVACUACIÓ
556209 | P0A - SECTORITZACIÓ I EVACUACIÓ
556319 | P0A - SECTORITZACIÓ I EVACUACIÓ
556401 | P0A - SECTORITZACIÓ I EVACUACIÓ
556485 | P0A - SECTORITZACIÓ I EVACUACIÓ
556542 | P0A - SECTORITZACIÓ I EVACUACIÓ
556574 | P0A - SECTORITZACIÓ I EVACUACIÓ
556603 | P0A - SECTORITZACIÓ I EVACUACIÓ
556604 | P0A - SECTORITZACIÓ I EVACUACIÓ
556640 | Nivel 1
556641 | Nivel 1
556695 | Nivel 1
556709 | Nivel 1
556717 | Nivel 1
556763 | Nivel 1
556797 | Nivel 1
556805 | Nivel 1
556834 | Nivel 1
556849 | Nivel 1
556897 | Nivel 1
556909 | Nivel 1
556932 | Nivel 1
556948 | Nivel 1
556964 | Nivel 1
556979 | Nivel 1
557001 | Nivel 1
557009 | Nivel 1
557017 | Nivel 1
557025 | Nivel 1
557033 | Nivel 1
557041 | Nivel 1
557051 | Nivel 1
557061 | Nivel 1
557079 | Nivel 1
557102 | Nivel 1
557123 | Nivel 1
557131 | Nivel 1
557139 | Nivel 1
557163 | Nivel 1
557204 | P02 - SECTORITZACIÓ I EVACUACIÓ
557234 | P02 - SECTORITZACIÓ I EVACUACIÓ
557251 | P02 - SECTORITZACIÓ I EVACUACIÓ
557270 | P02 - SECTORITZACIÓ I EVACUACIÓ
557287 | P02 - SECTORITZACIÓ I EVACUACIÓ
557299 | P02 - SECTORITZACIÓ I EVACUACIÓ
557316 | P02 - SECTORITZACIÓ I EVACUACIÓ
557326 | P02 - SECTORITZACIÓ I EVACUACIÓ
557340 | P02 - SECTORITZACIÓ I EVACUACIÓ
557356 | P02 - SECTORITZACIÓ I EVACUACIÓ
557384 | P02 - SECTORITZACIÓ I EVACUACIÓ
557399 | P02 - SECTORITZACIÓ I EVACUACIÓ
557407 | P02 - SECTORITZACIÓ I EVACUACIÓ
557424 | P02 - SECTORITZACIÓ I EVACUACIÓ
557442 | P02 - SECTORITZACIÓ I EVACUACIÓ
557454 | P02 - SECTORITZACIÓ I EVACUACIÓ
557472 | P02 - SECTORITZACIÓ I EVACUACIÓ
557884 | P02 - SECTORITZACIÓ I EVACUACIÓ
557900 | P02 - SECTORITZACIÓ I EVACUACIÓ
557912 | P02 - SECTORITZACIÓ I EVACUACIÓ
557948 | P02 - SECTORITZACIÓ I EVACUACIÓ
557962 | P02 - SECTORITZACIÓ I EVACUACIÓ
557982 | P02 - SECTORITZACIÓ I EVACUACIÓ
557994 | P02 - SECTORITZACIÓ I EVACUACIÓ
558040 | P03 - SECTORITZACIÓ I EVACUACIÓ
558071 | P03 - SECTORITZACIÓ I EVACUACIÓ
558088 | P03 - SECTORITZACIÓ I EVACUACIÓ
558106 | P03 - SECTORITZACIÓ I EVACUACIÓ
558120 | P03 - SECTORITZACIÓ I EVACUACIÓ
558132 | P03 - SECTORITZACIÓ I EVACUACIÓ
558146 | P03 - SECTORITZACIÓ I EVACUACIÓ
558167 | P03 - SECTORITZACIÓ I EVACUACIÓ
558177 | P03 - SECTORITZACIÓ I EVACUACIÓ
558194 | P03 - SECTORITZACIÓ I EVACUACIÓ
558207 | P03 - SECTORITZACIÓ I EVACUACIÓ
558229 | P03 - SECTORITZACIÓ I EVACUACIÓ
558245 | P03 - SECTORITZACIÓ I EVACUACIÓ
558289 | P03 - SECTORITZACIÓ I EVACUACIÓ
558290 | P03 - SECTORITZACIÓ I EVACUACIÓ
558342 | P03 - SECTORITZACIÓ I EVACUACIÓ
558360 | P03 - SECTORITZACIÓ I EVACUACIÓ
558398 | P03 - SECTORITZACIÓ I EVACUACIÓ
558400 | P03 - SECTORITZACIÓ I EVACUACIÓ
558414 | P03 - SECTORITZACIÓ I EVACUACIÓ
558430 | P03 - SECTORITZACIÓ I EVACUACIÓ
558449 | P03 - SECTORITZACIÓ I EVACUACIÓ
558465 | P03 - SECTORITZACIÓ I EVACUACIÓ
558523 | P04 - SECTORITZACIÓ I EVACUACIÓ
558584 | P04 - SECTORITZACIÓ I EVACUACIÓ
558600 | P04 - SECTORITZACIÓ I EVACUACIÓ
558615 | P04 - SECTORITZACIÓ I EVACUACIÓ
558623 | P04 - SECTORITZACIÓ I EVACUACIÓ
558638 | P04 - SECTORITZACIÓ I EVACUACIÓ
558639 | P04 - SECTORITZACIÓ I EVACUACIÓ
558661 | P04 - SECTORITZACIÓ I EVACUACIÓ
558669 | P04 - SECTORITZACIÓ I EVACUACIÓ
558684 | P04 - SECTORITZACIÓ I EVACUACIÓ
558697 | P04 - SECTORITZACIÓ I EVACUACIÓ
558715 | P04 - SECTORITZACIÓ I EVACUACIÓ
558738 | P04 - SECTORITZACIÓ I EVACUACIÓ
558739 | P04 - SECTORITZACIÓ I EVACUACIÓ
558740 | P04 - SECTORITZACIÓ I EVACUACIÓ
558741 | P04 - SECTORITZACIÓ I EVACUACIÓ
558742 | P04 - SECTORITZACIÓ I EVACUACIÓ
558743 | P04 - SECTORITZACIÓ I EVACUACIÓ
558769 | P04 - SECTORITZACIÓ I EVACUACIÓ
558797 | P04 - SECTORITZACIÓ I EVACUACIÓ
558823 | P04 - SECTORITZACIÓ I EVACUACIÓ
558837 | P04 - SECTORITZACIÓ I EVACUACIÓ
558872 | P05 - SECTORITZACIÓ I EVACUACIÓ
558888 | P05 - SECTORITZACIÓ I EVACUACIÓ
558906 | P05 - SECTORITZACIÓ I EVACUACIÓ
558912 | P05 - SECTORITZACIÓ I EVACUACIÓ
558918 | P05 - SECTORITZACIÓ I EVACUACIÓ
558926 | P05 - SECTORITZACIÓ I EVACUACIÓ
558938 | P05 - SECTORITZACIÓ I EVACUACIÓ
558954 | P05 - SECTORITZACIÓ I EVACUACIÓ
558971 | P05 - SECTORITZACIÓ I EVACUACIÓ
558991 | P05 - SECTORITZACIÓ I EVACUACIÓ
559009 | P05 - SECTORITZACIÓ I EVACUACIÓ
559023 | P05 - SECTORITZACIÓ I EVACUACIÓ
559048 | P05 - SECTORITZACIÓ I EVACUACIÓ
559102 | P05 - SECTORITZACIÓ I EVACUACIÓ
559110 | P05 - SECTORITZACIÓ I EVACUACIÓ
559118 | P05 - SECTORITZACIÓ I EVACUACIÓ
559148 | P05 - SECTORITZACIÓ I EVACUACIÓ
559149 | P05 - SECTORITZACIÓ I EVACUACIÓ
559150 | P05 - SECTORITZACIÓ I EVACUACIÓ
559151 | P05 - SECTORITZACIÓ I EVACUACIÓ
559152 | P05 - SECTORITZACIÓ I EVACUACIÓ
559180 | P05 - SECTORITZACIÓ I EVACUACIÓ
559192 | P05 - SECTORITZACIÓ I EVACUACIÓ
559208 | P05 - SECTORITZACIÓ I EVACUACIÓ
559226 | P05 - SECTORITZACIÓ I EVACUACIÓ
559252 | P05 - SECTORITZACIÓ I EVACUACIÓ
559279 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
631796 | P00 - SECTORITZACIÓ I EVACUACIÓ
631895 | P00 - SECTORITZACIÓ I EVACUACIÓ
632132 | P0A - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_06.03 Emer Sostre Rect:02 Emergencia Superficie 02 (57)
Type - Material: <Unnamed>, Vidrio
Classification: 50.60.50.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 02 Emergencia Superficie 02; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 02 Emergencia Superficie 02; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.052595 m2; ICAT-Volum: 0.0008604 m3
Name (ZYR_06.03 Emer Sostre Rect:02 Emergencia Superficie 02:...) | In
554191 | P00 - SECTORITZACIÓ I EVACUACIÓ
554222 | P00 - SECTORITZACIÓ I EVACUACIÓ
554230 | P00 - SECTORITZACIÓ I EVACUACIÓ
554272 | P00 - SECTORITZACIÓ I EVACUACIÓ
554286 | P00 - SECTORITZACIÓ I EVACUACIÓ
554294 | P00 - SECTORITZACIÓ I EVACUACIÓ
554306 | P00 - SECTORITZACIÓ I EVACUACIÓ
554318 | P00 - SECTORITZACIÓ I EVACUACIÓ
554336 | P00 - SECTORITZACIÓ I EVACUACIÓ
554483 | P00 - SECTORITZACIÓ I EVACUACIÓ
554507 | P00 - SECTORITZACIÓ I EVACUACIÓ
554788 | P0A - SECTORITZACIÓ I EVACUACIÓ
554839 | P0A - SECTORITZACIÓ I EVACUACIÓ
554853 | P0A - SECTORITZACIÓ I EVACUACIÓ
554873 | P0A - SECTORITZACIÓ I EVACUACIÓ
554883 | P0A - SECTORITZACIÓ I EVACUACIÓ
554891 | P0A - SECTORITZACIÓ I EVACUACIÓ
555185 | P0A - SECTORITZACIÓ I EVACUACIÓ
555201 | P0A - SECTORITZACIÓ I EVACUACIÓ
555216 | P0A - SECTORITZACIÓ I EVACUACIÓ
556636 | Nivel 1
556637 | Nivel 1
556638 | Nivel 1
556639 | Nivel 1
556642 | Nivel 1
556643 | Nivel 1
556644 | Nivel 1
557179 | P02 - SECTORITZACIÓ I EVACUACIÓ
557180 | P02 - SECTORITZACIÓ I EVACUACIÓ
557181 | P02 - SECTORITZACIÓ I EVACUACIÓ
557182 | P02 - SECTORITZACIÓ I EVACUACIÓ
557183 | P02 - SECTORITZACIÓ I EVACUACIÓ
557184 | P02 - SECTORITZACIÓ I EVACUACIÓ
557185 | P02 - SECTORITZACIÓ I EVACUACIÓ
558010 | P03 - SECTORITZACIÓ I EVACUACIÓ
558011 | P03 - SECTORITZACIÓ I EVACUACIÓ
558012 | P03 - SECTORITZACIÓ I EVACUACIÓ
558013 | P03 - SECTORITZACIÓ I EVACUACIÓ
558014 | P03 - SECTORITZACIÓ I EVACUACIÓ
558015 | P03 - SECTORITZACIÓ I EVACUACIÓ
558016 | P03 - SECTORITZACIÓ I EVACUACIÓ
558507 | P04 - SECTORITZACIÓ I EVACUACIÓ
558508 | P04 - SECTORITZACIÓ I EVACUACIÓ
558509 | P04 - SECTORITZACIÓ I EVACUACIÓ
558510 | P04 - SECTORITZACIÓ I EVACUACIÓ
558511 | P04 - SECTORITZACIÓ I EVACUACIÓ
558512 | P04 - SECTORITZACIÓ I EVACUACIÓ
558513 | P04 - SECTORITZACIÓ I EVACUACIÓ
558544 | P04 - SECTORITZACIÓ I EVACUACIÓ
558557 | P04 - SECTORITZACIÓ I EVACUACIÓ
558844 | P05 - SECTORITZACIÓ I EVACUACIÓ
558845 | P05 - SECTORITZACIÓ I EVACUACIÓ
558846 | P05 - SECTORITZACIÓ I EVACUACIÓ
558847 | P05 - SECTORITZACIÓ I EVACUACIÓ
558848 | P05 - SECTORITZACIÓ I EVACUACIÓ
558859 | P05 - SECTORITZACIÓ I EVACUACIÓ
559269 | P05 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_06.03 Emer Sostre Rect:06 Emergencia Estanca 01 (58)
Type - Material: <Unnamed>, Vidrio
Classification: 50.60.50.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 06 Emergencia Estanca 01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: 06 Emergencia Estanca 01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.052595 m2; ICAT-Volum: 0.0008604 m3
Name (ZYR_06.03 Emer Sostre Rect:06 Emergencia Estanca 01:...) | In
548002 | PS2 - SECTORITZACIÓ I EVACUACIÓ
548060 | PS2 - SECTORITZACIÓ I EVACUACIÓ
548072 | PS2 - SECTORITZACIÓ I EVACUACIÓ
548088 | PS2 - SECTORITZACIÓ I EVACUACIÓ
548096 | PS2 - SECTORITZACIÓ I EVACUACIÓ
548108 | PS2 - SECTORITZACIÓ I EVACUACIÓ
548126 | PS2 - SECTORITZACIÓ I EVACUACIÓ
553187 | PS2 - SECTORITZACIÓ I EVACUACIÓ
553296 | PS2 - SECTORITZACIÓ I EVACUACIÓ
553341 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553417 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553434 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553448 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553458 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553481 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553513 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553530 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553545 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553561 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553573 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553657 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553673 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553681 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553696 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553732 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553744 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553752 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553762 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553778 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553792 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553811 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553839 | PS1 - SECTORITZACIÓ I EVACUACIÓ
553849 | PS1 - SECTORITZACIÓ I EVACUACIÓ
554125 | P00 - SECTORITZACIÓ I EVACUACIÓ
554133 | P00 - SECTORITZACIÓ I EVACUACIÓ
559320 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
559370 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
559478 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
628470 | PS1 - SECTORITZACIÓ I EVACUACIÓ
628540 | PS1 - SECTORITZACIÓ I EVACUACIÓ
631383 | PS1 - SECTORITZACIÓ I EVACUACIÓ
678651 | PS1 - SECTORITZACIÓ I EVACUACIÓ
678947 | PS1 - SECTORITZACIÓ I EVACUACIÓ
678991 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679007 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679015 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679023 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679031 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679049 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679069 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679077 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679095 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679118 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679126 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679144 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679145 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679161 | PS1 - SECTORITZACIÓ I EVACUACIÓ
701240 | PS1 - SECTORITZACIÓ I EVACUACIÓ

# IfcBuildingElementProxy: ZYR_08.01.01 RACK (Armari Petit):RACK P0A (EXISTENT), ZYR_08.01.01 RACK (Armari Petit):RACK P0A (EXISTENT):753080
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>, Vidrio
Classification: 50.70.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: RACK P0A (EXISTENT); sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RACK P0A (EXISTENT); ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 1.03225 m2; ICAT-Volum: 0.136125 m3

# IfcBuildingElementProxy: ZYR_08.01.01 RACK (Armari Petit):RACK P1 (EXISTENT), ZYR_08.01.01 RACK (Armari Petit):RACK P1 (EXISTENT):753020
In: Nivel 1
Type - Material: <Unnamed>, Vidrio
Classification: 50.70.10.30 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: RACK P1 (EXISTENT); sets with these values: 2
