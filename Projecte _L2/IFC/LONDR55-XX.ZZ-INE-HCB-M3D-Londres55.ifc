Properties of the parts of a building model (IFC2X3), part 8 of 9

# IfcFlowSegment: Tipos de tubería:CLI.Aigua (Acer Negre) (261)
Name (Tipos de tubería:CLI.Aigua (Acer Negre):...) | In | Pset_DuctSegmentTypeCommon, Length (m) = Pset_FlowSegmentDuctSegment, Length (m) = ICAT-Llarg (m) | ICAT-Superficie (m2) | Group
775554 | P04 - SECTORITZACIÓ I EVACUACIÓ | 1.2691 | 0.07974 | AFIS 1
775565 | P04 - SECTORITZACIÓ I EVACUACIÓ | 1.18751 | 0.0746134 | AFIP 1
775862 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.627613 | 0.0394341 | ACIS 1
775960 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.627613 | 0.0394341 | ACIP 2
776170 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.627612 | 0.0394341 | AFIS 1
776231 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.627612 | 0.0394341 | AFIS 2
776290 | P04 - SECTORITZACIÓ I EVACUACIÓ | 3.36779 | 0.211605 | ACIS 2
776292 | P04 - SECTORITZACIÓ I EVACUACIÓ | 3.44779 | 0.216631 | ACIP 1
776294 | P04 - SECTORITZACIÓ I EVACUACIÓ | 3.52779 | 0.221658 | AFIS 3
776296 | P04 - SECTORITZACIÓ I EVACUACIÓ | 3.60939 | 0.226784 | AFIP 2
776533 | P04 - SECTORITZACIÓ I EVACUACIÓ | 2.29662 | 0.144301 | ACIS 2
776604 | P04 - SECTORITZACIÓ I EVACUACIÓ | 2.37662 | 0.149327 | ACIP 1
776662 | P04 - SECTORITZACIÓ I EVACUACIÓ | 3.95264 | 0.248352 | AFIS 3
776724 | P04 - SECTORITZACIÓ I EVACUACIÓ | 4.13329 | 0.259702 | AFIP 2
776785 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.650025 | 0.0408423 | AFIP 3
776893 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.650025 | 0.0408423 | ACIP 1
777083 | P04 - SECTORITZACIÓ I EVACUACIÓ | 6.2651 | 0.393648 | AFIP 1
777177 | P04 - SECTORITZACIÓ I EVACUACIÓ | 6.18351 | 0.388521 | AFIS 1
777243 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.126668 | 0.00795876 | AFIP 1
777245 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.125075 | 0.00785869 | AFIS 1
777482 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0205839 | 0.00129333 | ACIS 1
777521 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0205839 | 0.00129333 | ACIP 2
777546 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0194536 | 0.0012223 | AFIS 1
777621 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0194536 | 0.0012223 | AFIS 2
777656 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.166668 | 0.010472 | AFIP 2
777904 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0152323 | 0.000957075 | AFIP 3; ACIP 3
777951 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0152323 | 0.000957075 | ACIP 1
777990 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.650025 | 0.0408423 | AFIP 4
778031 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.650025 | 0.0408423 | AFIP 2
778162 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0641301 | 0.00402941 | AFIP 2
778194 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.005075 | 0.000318872 | AFIS 3
778329 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0308671 | 0.00193944 | AFIP 4
778363 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0308671 | 0.00193944 | AFIP 2
778604 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.450729 | 0.0283201 | ACIS 3
778606 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.400729 | 0.0251785 | ACIP 4
778734 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.391261 | 0.0245837 | AFIP 6
778792 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.459227 | 0.0288541 | AFIS 5
779007 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.610075 | 0.0383321 | ACIS 3
779059 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.610075 | 0.0383321 | ACIP 4
779151 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.049999 | 0.00314153 | ACIS 3
779535 | P03 - SECTORITZACIÓ I EVACUACIÓ | 1.29911 | 0.0816257 | AFIP 6
779537 | P03 - SECTORITZACIÓ I EVACUACIÓ | 1.36773 | 0.0859372 | AFIS 5
779600 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.610075 | 0.0383321 | AFIP 6
779657 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.610075 | 0.0383321 | AFIS 5
779686 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00935713 | 0.000587926 | AFIP 6
779803 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.00935713 | 0.000587926 | AFIS 5
779838 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0236692 | 0.00148718 | ACIP 4
779879 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0149868 | 0.00094165 | ACIS 3
779909 | P03 - SECTORITZACIÓ I EVACUACIÓ | 3.36779 | 0.211605 | ACIS 4
779911 | P03 - SECTORITZACIÓ I EVACUACIÓ | 3.44779 | 0.216631 | ACIP 5
779913 | P03 - SECTORITZACIÓ I EVACUACIÓ | 3.52779 | 0.221658 | AFIS 4
779915 | P03 - SECTORITZACIÓ I EVACUACIÓ | 3.60939 | 0.226784 | AFIP 5
779917 | P03 - SECTORITZACIÓ I EVACUACIÓ | 2.29662 | 0.144301 | ACIS 4
779919 | P03 - SECTORITZACIÓ I EVACUACIÓ | 2.37662 | 0.149327 | ACIP 5
779921 | P03 - SECTORITZACIÓ I EVACUACIÓ | 3.95264 | 0.248352 | AFIS 4
779923 | P03 - SECTORITZACIÓ I EVACUACIÓ | 4.13329 | 0.259702 | AFIP 5
779925 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.650025 | 0.0408423 | ACIS 4; AFIP 8
779929 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.650025 | 0.0408423 | ACIP 5
779933 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.166668 | 0.010472 | AFIP 5
779937 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.650025 | 0.0408423 | AFIS 4; AFIP 9
779939 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.650025 | 0.0408423 | AFIP 5
779941 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0641301 | 0.00402941 | AFIP 5
779943 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.005075 | 0.000318872 | AFIS 4
780289 | P02 - SECTORITZACIÓ I EVACUACIÓ | 7.91452 | 0.497284 | ACIS 5
780291 | P02 - SECTORITZACIÓ I EVACUACIÓ | 7.8296 | 0.491948 | ACIP 6
780293 | P02 - SECTORITZACIÓ I EVACUACIÓ | 7.67293 | 0.482104 | AFIP 7
780295 | P02 - SECTORITZACIÓ I EVACUACIÓ | 7.75452 | 0.487231 | AFIS 6
781488 | P02 - SECTORITZACIÓ I EVACUACIÓ | 1.57981 | 0.0992622 | ACIS 5
781490 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.384953 | 0.0241873 | ACIP 6
781691 | P02 - SECTORITZACIÓ I EVACUACIÓ | 1.57981 | 0.0992622 | AFIS 6
781777 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.384953 | 0.0241873 | AFIP 7
781897 | P02 - SECTORITZACIÓ I EVACUACIÓ | 2.68555 | 0.168738 | ACIS 5
781899 | P02 - SECTORITZACIÓ I EVACUACIÓ | 2.8654 | 0.180038 | ACIP 6
781901 | P02 - SECTORITZACIÓ I EVACUACIÓ | 4.10555 | 0.257959 | AFIS 6
781903 | P02 - SECTORITZACIÓ I EVACUACIÓ | 4.26873 | 0.268212 | AFIP 7
782172 | P02 - SECTORITZACIÓ I EVACUACIÓ | 1.8499 | 0.116233 | ACIS 5
782174 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.676745 | 0.0425212 | ACIP 6
782176 | P02 - SECTORITZACIÓ I EVACUACIÓ | 2.06438 | 0.129709 | AFIS 6
782178 | P02 - SECTORITZACIÓ I EVACUACIÓ | 2.24032 | 0.140763 | AFIP 7
782235 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.043725 | 0.00274732 | AFIP 7
782238 | P02 - SECTORITZACIÓ I EVACUACIÓ | 1.57981 | 0.0992622 | AFIP 7
782270 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.043725 | 0.00274732 | AFIS 6
782273 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.384953 | 0.0241873 | AFIS 6
782306 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.043725 | 0.00274732 | ACIP 6
782309 | P02 - SECTORITZACIÓ I EVACUACIÓ | 1.57981 | 0.0992622 | ACIP 6
782345 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.043725 | 0.00274732 | ACIS 5
782348 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.374953 | 0.023559 | ACIS 5
782447 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.182329 | 0.0114561 | ACIS 5
782449 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00261688 | 0.000164423 | ACIP 6
782451 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.650075 | 0.0408454 | AFIS 6
782453 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.731668 | 0.045972 | AFIP 7
782531 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.258086 | 0.016216 | AFIS 6
782533 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.439679 | 0.0276258 | AFIP 7
782572 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.198086 | 0.0124461 | ACIS 5
782574 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.18301 | 0.0114989 | ACIP 6
782589 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0980861 | 0.00616293 | ACIS 5
782984 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.339679 | 0.0213426 | AFIS 8
782986 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.358086 | 0.0224992 | AFIP 11
783053 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.043725 | 0.00274732 | AFIP 7; AFIS 8
783056 | P02 - SECTORITZACIÓ I EVACUACIÓ | 1.9012 | 0.119456 | AFIP 7
783095 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.043725 | 0.00274732 | AFIS 6; AFIP 11
783098 | P02 - SECTORITZACIÓ I EVACUACIÓ | 2.07713 | 0.13051 | AFIS 6
783177 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.043725 | 0.00274732 | ACIS 5
783180 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.833502 | 0.0523705 | ACIS 5
783217 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.244999 | 0.0153937 | ACIS 5
783242 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.160075 | 0.0100578 | ACIP 6
783340 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0384824 | 0.00241792 | AFIS 6
783366 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.120075 | 0.00754453 | AFIP 7
783408 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.750075 | 0.0471286 | AFIS 6; AFIP 10
783434 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.750075 | 0.0471286 | AFIP 7
783501 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0159203 | 0.0010003 | AFIP 7
783526 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0159203 | 0.0010003 | AFIP 10
783591 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.750075 | 0.0471286 | ACIS 5
783601 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0139355 | 0.000875596 | ACIS 5
783625 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.750075 | 0.0471286 | ACIP 6
783635 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0139355 | 0.000875596 | ACIP 6
783690 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0866676 | 0.00544548 | AFIP 11
783713 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.005075 | 0.000318872 | AFIS 8
783754 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.745075 | 0.0468144 | AFIS 8
783764 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0293278 | 0.00184272 | AFIS 8
783788 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.745075 | 0.0468144 | AFIP 11
783856 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0293278 | 0.00184272 | AFIP 11
784039 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.28301 | 0.0177821 | ACIS 8
784052 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0369076 | 0.00231897 | ACIS 8
784113 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.745075 | 0.0468144 | ACIS 8
784136 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.745075 | 0.0468144 | ACIS 5; ACIP 7
784295 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.043725 | 0.00274732 | ACIP 6; ACIS 8
784298 | P02 - SECTORITZACIÓ I EVACUACIÓ | 2.00666 | 0.126082 | ACIP 6
784330 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0050375 | 0.000316515 | ACIP 7
784372 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0050375 | 0.000316515 | ACIS 8
784432 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.535075 | 0.0336198 | ACIP 6
784504 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.535075 | 0.0336198 | ACIS 5
784597 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.482538 | 0.0303187 | AFIP 12
784624 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.482538 | 0.0303187 | AFIP 7
784735 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.52624 | 0.0330646 | ACIP 6
784836 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.431418 | 0.0271068 | ACIS 5
784868 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.039837 | 0.00250304 | ACIP 6
784936 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00759152 | 0.000476989 | ACIS 5
784974 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00759152 | 0.000476989 | ACIP 6
785265 | P02 - SECTORITZACIÓ I EVACUACIÓ | 4.18254 | 0.262797 | ACIS 6
785267 | P02 - SECTORITZACIÓ I EVACUACIÓ | 3.11753 | 0.19588 | AFIS 7
785269 | P02 - SECTORITZACIÓ I EVACUACIÓ | 3.03593 | 0.190753 | AFIP 13
785271 | P02 - SECTORITZACIÓ I EVACUACIÓ | 4.0905 | 0.257014 | ACIP 8
785451 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.042575 | 0.00267507 | ACIS 6
785510 | P02 - SECTORITZACIÓ I EVACUACIÓ | 1.25081 | 0.078591 | AFIP 13
785577 | P02 - SECTORITZACIÓ I EVACUACIÓ | 1.25081 | 0.078591 | AFIS 7
785781 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.938051 | 0.0589395 | AFIS 7
785818 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.050075 | 0.00314631 | AFIS 7
785847 | P02 - SECTORITZACIÓ I EVACUACIÓ | 1.11168 | 0.0698488 | AFIP 13
785855 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.131668 | 0.00827292 | AFIP 13
785890 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.785025 | 0.0493246 | AFIS 7
785900 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0309163 | 0.00194253 | AFIS 7
785926 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.785025 | 0.0493246 | AFIP 13
785936 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0309163 | 0.00194253 | AFIP 13
786023 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.785025 | 0.0493246 | ACIS 6
786033 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0173977 | 0.00109313 | ACIS 6
786056 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.785025 | 0.0493246 | ACIP 8
786068 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.00893039 | 0.000561113 | ACIP 8
786102 | Nivel 1 | 2.6613 | 0.167214 | ACIS 7
786104 | Nivel 1 | 1.4813 | 0.0930729 | AFIS 9
786106 | Nivel 1 | 1.39971 | 0.0879462 | AFIP 14
786108 | Nivel 1 | 2.57499 | 0.161791 | ACIP 9
786156 | Nivel 1 | 0.811042 | 0.0509593 | ACIS 7
786158 | Nivel 1 | 0.905075 | 0.0568675 | AFIS 9
786160 | Nivel 1 | 0.899745 | 0.0565327 | AFIP 14
786162 | Nivel 1 | 0.723133 | 0.0454358 | ACIP 9
786223 | Nivel 1 | 0.0310097 | 0.0019484 | AFIS 9
786485 | Nivel 1 | 0.103206 | 0.00648459 | AFIP 14
786493 | Nivel 1 | 0.0260097 | 0.00163424 | AFIP 14
786537 | Nivel 1 | 0.00268216 | 0.000168525 | AFIS 9
786736 | Nivel 1 | 0.645075 | 0.0405313 | AFIS 9
786750 | Nivel 1 | 0.0105264 | 0.000661393 | AFIS 9
786796 | Nivel 1 | 0.645075 | 0.0405313 | AFIP 14
786806 | Nivel 1 | 0.0096958 | 0.000609205 | AFIP 14
786850 | Nivel 1 | 0.882538 | 0.0554515 | ACIS 7; ACIP 10
786875 | Nivel 1 | 0.900075 | 0.0565534 | ACIP 9
786904 | Nivel 1 | 0.024718 | 0.00155308 | ACIP 9
786929 | Nivel 1 | 0.0777726 | 0.0048866 | ACIP 11
786969 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0827726 | 0.00520076 | ACIP 11
787676 | Nivel 1 | 0.507717 | 0.0319008 | AFIS 10
787678 | Nivel 1 | 0.594486 | 0.0373526 | AFIP 16
787717 | Nivel 1 | 0.589601 | 0.0370457 | ACIS 9
787719 | Nivel 1 | 0.423362 | 0.0266006 | ACIP 12
787748 | Nivel 1 | 0.0498805 | 0.00313409 | ACIS 9
787750 | Nivel 1 | 0.630075 | 0.0395888 | ACIP 12
787791 | Nivel 1 | 0.0478642 | 0.0030074 | AFIP 16
787905 | Nivel 1 | 0.630076 | 0.0395888 | AFIP 16
787930 | Nivel 1 | 0.630075 | 0.0395888 | AFIS 10
788067 | Nivel 1 | 0.0601465 | 0.00377911 | AFIS 10
788131 | Nivel 1 | 0.0601391 | 0.00377865 | AFIP 16
788167 | Nivel 1 | 0.630075 | 0.0395888 | ACIS 9
788217 | Nivel 1 | 0.079113 | 0.00497082 | ACIP 12
788242 | Nivel 1 | 0.079113 | 0.00497082 | ACIS 9
788529 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.483373 | 0.0303712 | ACIS 10
788531 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.289582 | 0.0181949 | AFIS 11
788533 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.222322 | 0.0139689 | AFIP 15
788535 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.412775 | 0.0259354 | ACIP 13
788638 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.61688 | 0.101592 | ACIS 10
788640 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.2954 | 0.0813925 | AFIS 11
788642 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.22814 | 0.0771665 | AFIP 15
788644 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.4826 | 0.0931546 | ACIP 13
788975 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.590075 | 0.0370755 | AFIP 17
788988 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0247844 | 0.00155725 | AFIP 17
789013 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.590075 | 0.0370755 | AFIP 15
789025 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0250887 | 0.00157637 | AFIP 15
789070 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.590075 | 0.0370755 | ACIP 13
789080 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0162829 | 0.00102309 | ACIP 13
789139 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.590075 | 0.0370755 | ACIS 10
789149 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0162829 | 0.00102309 | ACIS 10
789334 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.193588 | 0.0121635 | ACIS 10
789336 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.193284 | 0.0121444 | ACIP 13
789415 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.03898 | 0.0652812 | ACIS 10
789454 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.10268 | 0.0692835 | ACIP 13
789718 | P0A - SECTORITZACIÓ I EVACUACIÓ | 3.21012 | 0.201698 | ACIS 11
789720 | P0A - SECTORITZACIÓ I EVACUACIÓ | 3.02131 | 0.189835 | AFIS 12
789722 | P0A - SECTORITZACIÓ I EVACUACIÓ | 2.94097 | 0.184787 | AFIP 18
789724 | P0A - SECTORITZACIÓ I EVACUACIÓ | 3.12915 | 0.19661 | ACIP 14
790189 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.577171 | 0.0362647 | ACIS 11
790191 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.496204 | 0.0311774 | ACIP 14
790265 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.625594 | 0.0393073 | AFIS 12
790267 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.635075 | 0.0399029 | AFIP 18
790317 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.11416 | 0.0700046 | AFIS 12
790319 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.02433 | 0.0643608 | AFIP 18
790350 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.153883 | 0.00966875 | AFIS 12
790416 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.153258 | 0.0096295 | AFIP 18
790469 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.785025 | 0.0493246 | AFIP 19
790480 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0400435 | 0.00251601 | AFIP 19
790508 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.785025 | 0.0493246 | AFIP 18
790518 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0400435 | 0.00251601 | AFIP 18
790569 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.785025 | 0.0493246 | ACIS 11
790579 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0825375 | 0.00518598 | ACIS 11
790623 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.785025 | 0.0493246 | ACIP 14
790633 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0825375 | 0.00518598 | ACIP 14
790676 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.707537 | 0.0444559 | ACIP 15
790678 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.707537 | 0.0444559 | AFIS 13
790680 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.745037 | 0.0468121 | AFIP 20
790781 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.490075 | 0.0307923 | AFIP 20
790804 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.530075 | 0.0333056 | AFIS 13
790868 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.113288 | 0.00711808 | AFIS 13
790912 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0454176 | 0.00285367 | AFIP 20
790960 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0757877 | 0.00476188 | AFIP 20
791067 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.745037 | 0.0468121 | ACIS 12
791075 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0460423 | 0.00289292 | ACIS 12
791105 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.530075 | 0.0333056 | ACIP 15
791129 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.490075 | 0.0307923 | ACIS 12
791141 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0757877 | 0.00476188 | ACIS 12
791179 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.100037 | 0.00628554 | ACIP 15
791245 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.770037 | 0.0483829 | ACIP 16
791247 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.807538 | 0.0507391 | ACIS 13
791249 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0460423 | 0.00289292 | ACIS 13
791253 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.530075 | 0.0333056 | ACIP 16
791257 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.490075 | 0.0307923 | ACIS 13
791261 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0757877 | 0.00476188 | ACIS 13
791265 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.100037 | 0.00628554 | ACIP 16
791312 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.707537 | 0.0444559 | AFIS 14
791314 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.745037 | 0.0468121 | AFIP 21
791316 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.490075 | 0.0307923 | AFIP 21
791318 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.530075 | 0.0333056 | AFIS 14
791322 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0454176 | 0.00285367 | AFIP 21

# IfcFlowSegment: Tipos de tubería:FON.Coure (40)
Pset_DistributionFlowElementCommon - Reference: FON.Coure; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: FON.Coure; ICAT_04-EstatusObra: Nueva construcción
Name (Tipos de tubería:FON.Coure:...) | In | Pset_DuctSegmentTypeCommon, Length (m) = Pset_FlowSegmentDuctSegment, Length (m) = ICAT-Llarg (m) | ICAT-Superficie (m2) | Group
684574 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.615679 | 0.0290132 | AFS 3
684664 | P00 - SECTORITZACIÓ I EVACUACIÓ | 1.14457 | 0.0539364 | AFS 1
684889 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.405713 | 0.0191188 | AFS 1
684953 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.74152 | 0.0349433 | AFS 3
684962 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.177917 | 0.00838412 | AFS 3
688290 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.465075 | 0.0219161 | AFS 3
689859 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0254 | 0.00119695 | AFS 3
689860 | P00 - SECTORITZACIÓ I EVACUACIÓ | 2.09812 | 0.0988715 | AFS 3
689916 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.394619 | 0.018596 | AFS 3
689924 | P00 - SECTORITZACIÓ I EVACUACIÓ | 1.02512 | 0.0483077 | AFS 3
689970 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0504 | 0.00237504 | AFS 3
689971 | P00 - SECTORITZACIÓ I EVACUACIÓ | 2.21363 | 0.104315 | AFS 3
690172 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00650925 | 0.000306741 | AFS 1
690211 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.0254 | 0.00119695 | AFS 1
690212 | P00 - SECTORITZACIÓ I EVACUACIÓ | 2.23386 | 0.105268 | AFS 1
690611 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.552648 | 0.0260429 | AFS 2
690748 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.880484 | 0.0414918 | AFS 2
690753 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.384175 | 0.0181038 | AFS 2
695177 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.440229 | 0.0207453 | AFS 3
697098 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00976875 | 0.00331446 | SAN_Fecal Enterrat 1
697116 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.511341 | 0.173494 | SAN_Fecal Enterrat 1
697130 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.149654 | 0.0507763 | SAN_Fecal Enterrat 1
697333 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.13301 | 0.0451291 | SAN_Fecal Enterrat 1
793669 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.552648 | 0.0260429 | AFS 4
793676 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.70706 | 0.0804435 | AFS 4
794537 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.865194 | 0.0407713 | AFS 4
794621 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.135353 | 0.00637837 | AFS 4
794658 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0254 | 0.00119695 | AFS 4
794659 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.71386 | 0.0807636 | AFS 4
794744 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.207064 | 0.00975768 | AFS 2
795217 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.49258 | 0.0703359 | AFS 2
795226 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.356347 | 0.0167924 | AFS 2
795256 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0254 | 0.00119695 | AFS 2
795257 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.58632 | 0.0747535 | AFS 2
795359 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.107853 | 0.00508247 | AFS 2
795397 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0254 | 0.00119695 | AFS 2
795398 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.70386 | 0.0802923 | AFS 2
795432 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.00476875 | 0.001618 | SAN_Fecal Aeri 2
795448 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.435174 | 0.147651 | SAN_Fecal Aeri 2
795462 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0917584 | 0.0311329 | SAN_Fecal Aeri 2

# IfcFlowSegment: Tipos de tubería:SAN.PVC (20)
Pset_DistributionFlowElementCommon - Reference: SAN.PVC; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: SAN.PVC; ICAT_04-EstatusObra: Nueva construcción
Name (Tipos de tubería:SAN.PVC:...) | In | Pset_DuctSegmentTypeCommon, Length (m) = Pset_FlowSegmentDuctSegment, Length (m) = ICAT-Llarg (m) | ICAT-Superficie (m2) | Group
695265 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.0270625 | 0.00935213 | SAN_Fecal Aeri 1
695307 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.438579 | 0.151562 | SAN_Fecal Aeri 1
695339 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.144813 | 0.0500437 | SAN_Fecal Aeri 1
695812 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.00269184 | 0.000930234 | SAN_Fecal Enterrat 1
695828 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.495827 | 0.171345 | SAN_Fecal Enterrat 1
695839 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.250444 | 0.0865473 | SAN_Fecal Enterrat 1
696003 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.106725 | 0.0368816 | SAN_Fecal Enterrat 1
696145 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.013283 | 0.00166919 | SAN_Fecal Enterrat 1
696180 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.932374 | 0.117166 | SAN_Fecal Enterrat 1
696427 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.013283 | 0.00166919 | SAN_Fecal Aeri 1
696429 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.889293 | 0.111752 | SAN_Fecal Aeri 1
696433 | P0A - SECTORITZACIÓ I EVACUACIÓ | 1.82103 | 0.228838 | SAN_Fecal Aeri 1
696614 | P00 - SECTORITZACIÓ I EVACUACIÓ | 3.97334 | 1.37309 | SAN_Fecal Aeri 1
696632 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.559283 | 0.193274 | SAN_Fecal Aeri 1
696724 | P00 - SECTORITZACIÓ I EVACUACIÓ | 0.537652 | 0.0675634 | SAN_Fecal Enterrat 1
696857 | P00 - SECTORITZACIÓ I EVACUACIÓ | 1.44644 | 0.181765 | SAN_Fecal Enterrat 1
697014 | P00 - SECTORITZACIÓ I EVACUACIÓ | 1.83277 | 0.633358 | SAN_Fecal Enterrat 1
697030 | P00 - SECTORITZACIÓ I EVACUACIÓ | 1.02712 | 0.354946 | SAN_Fecal Enterrat 1
697349 | P00 - SECTORITZACIÓ I EVACUACIÓ | 1.5375 | 0.531321 | SAN_Fecal Enterrat 1
795542 | P00 - SECTORITZACIÓ I EVACUACIÓ | 1.86977 | 0.646146 | SAN_Fecal Aeri 2

# IfcFlowTerminal: ZYR_03.06.04.01 Boca Extracció Circular:BE01 (3)
Type - Material: <Unnamed>
Classification: 50.30.50.50 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: BE01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: BE01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.033308 m2; ICAT-Volum: 0.000221668 m3
Name (ZYR_03.06.04.01 Boca Extracció Circular:BE01:...) | In | Group
441273 | P00 - SECTORITZACIÓ I EVACUACIÓ | AEWC 2
444373 | P0A - SECTORITZACIÓ I EVACUACIÓ | AEWC 1
804675 | P00 - SECTORITZACIÓ I EVACUACIÓ | AE 3

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Extracció:RE01 (4)
In: PS1 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat); Group: AEPK 1
Pset_DistributionFlowElementCommon - Reference: RE01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RE01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.210065 m2; ICAT-Volum: 0.00173965 m3
Name (ZYR_03.06.04.01 Reixa Paret Extracció:RE01:...)
424402
424586
424676
424684

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Extracció:RE02, ZYR_03.06.04.01 Reixa Paret Extracció:RE02:764122
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat); Group: AE 2
Pset_DistributionFlowElementCommon - Reference: RE02; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RE02; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.134705 m2; ICAT-Volum: 0.0021393 m3

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Impulsió:RI03, ZYR_03.06.04.01 Reixa Paret Impulsió:RI03:765292
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat); Group: AI 25
Pset_DistributionFlowElementCommon - Reference: RI03; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RI03; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.307705 m2; ICAT-Volum: 0.00272805 m3

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Impulsió:RI04 (27)
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RI04; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RI04; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.040505 m2; ICAT-Volum: 0.00029605 m3
Name (ZYR_03.06.04.01 Reixa Paret Impulsió:RI04:...) | In | Group
482266 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
482548 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
482747 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
483046 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
483113 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
483323 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
495092 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
495236 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
495251 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
496250 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
498567 | Nivel 1 | AI 19
498662 | Nivel 1 | AI 19
498850 | Nivel 1 | AI 19
498905 | Nivel 1 | AI 19
499451 | Nivel 1 | AI 19
499461 | Nivel 1 | AI 19
499471 | Nivel 1 | AI 19
499479 | Nivel 1 | AI 19
499491 | Nivel 1 | AI 19
499499 | Nivel 1 | AI 19
499507 | Nivel 1 | AI 19
499517 | Nivel 1 | AI 19
500067 | Nivel 1 | AI 19
500135 | Nivel 1 | AI 19
500247 | Nivel 1 | AI 19
506561 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18
506943 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Retorn:RR01_V (35)
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RR01_V; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RR01_V; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.040505 m2; ICAT-Volum: 0.00029605 m3
Name (ZYR_03.06.04.01 Reixa Paret Retorn:RR01_V:...) | In | Group
478047 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 31
478198 | P04 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 21
478436 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 13
479044 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 33
479390 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 14
480181 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 16
480377 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 17
480537 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 17
481091 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 16
491255 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 19
492552 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 8
492679 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 8
493945 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 10
494008 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 11
494021 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 12
494032 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 8
502272 | Nivel 1 | Mecánica Aire de retorno 37
502382 | Nivel 1 | Mecánica Aire de retorno 38
502390 | Nivel 1 | Mecánica Aire de retorno 35
502398 | Nivel 1 | Mecánica Aire de retorno 36
502406 | Nivel 1 | Mecánica Aire de retorno 34
502416 | Nivel 1 | Mecánica Aire de retorno 9
502424 | Nivel 1 | Mecánica Aire de retorno 20
502436 | Nivel 1 | Mecánica Aire de retorno 40
502446 | Nivel 1 | Mecánica Aire de retorno 39
502456 | Nivel 1 | Mecánica Aire de retorno 41
503624 | Nivel 1 | Mecánica Aire de retorno 64
503748 | Nivel 1 | Mecánica Aire de retorno 63
504297 | Nivel 1 | Mecánica Aire de retorno 62
504409 | Nivel 1 | Mecánica Aire de retorno 61
504656 | Nivel 1 | Mecánica Aire de retorno 43
507520 | P05 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 29
507594 | P05 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 53
507820 | P05 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 30
507946 | P05 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 27

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Retorn:RR02_V (5)
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RR02_V; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RR02_V; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.072305 m2; ICAT-Volum: 0.00055405 m3
Name (ZYR_03.06.04.01 Reixa Paret Retorn:RR02_V:...) | In | Group
479702 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 15
480749 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 17
491396 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 7
493205 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 8
507996 | P05 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 54

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Retorn:RR03_V, ZYR_03.06.04.01 Reixa Paret Retorn:RR03_V:518171
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat); Group: Mecánica Aire de retorno 55
Pset_DistributionFlowElementCommon - Reference: RR03_V; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RR03_V; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.092305 m2; ICAT-Volum: 0.00075405 m3

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Retorn:RR04_V (2)
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RR04_V; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RR04_V; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.307705 m2; ICAT-Volum: 0.00272805 m3
Name (ZYR_03.06.04.01 Reixa Paret Retorn:RR04_V:...) | Group
516222 | Mecánica Aire de retorno 2
767861 | Mecánica Aire de retorno 45

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Retorn:RR07_V (4)
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RR07_V; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RR07_V; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.307705 m2; ICAT-Volum: 0.00272805 m3
Name (ZYR_03.06.04.01 Reixa Paret Retorn:RR07_V:...) | In | Group
483499 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 18
504891 | Nivel 1 | Mecánica Aire de retorno 24
509209 | P05 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 26
518882 | P00 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 32

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Retorn:RR08_V, ZYR_03.06.04.01 Reixa Paret Retorn:RR08_V:494490
In: P02 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat); Group: Mecánica Aire de retorno 56
Pset_DistributionFlowElementCommon - Reference: RR08_V; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RR08_V; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.221805 m2; ICAT-Volum: 0.00189905 m3

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Sobrepressio:RA01 (5)
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RA01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RA01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.406105 m2; ICAT-Volum: 0.0070633 m3
Name (ZYR_03.06.04.01 Reixa Paret Sobrepressio:RA01:...) | In | Group
404465 | P00 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire Aportació PK 1
519436 | PS1 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire Aportació PK EI 2
519577 | PS1 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire Aportació PK EI 2
519588 | PS1 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire Aportació PK EI 2
519599 | PS1 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire Aportació PK EI 2

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Sobrepressio:RA02, ZYR_03.06.04.01 Reixa Paret Sobrepressio:RA02:408410
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat); Group: ASP 6
Pset_DistributionFlowElementCommon - Reference: RA02; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RA02; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.593705 m2; ICAT-Volum: 0.0104793 m3

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Sobrepressio:RA03, ZYR_03.06.04.01 Reixa Paret Sobrepressio:RA03:764476
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat); Group: AP 1
Pset_DistributionFlowElementCommon - Reference: RA03; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RA03; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.097805 m2; ICAT-Volum: 0.0014853 m3

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Paret Sobrepressio:RS01_V (8)
Type - Material: Reixa, <Unnamed>
Classification: 50.30.50.50 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RS01_V; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RS01_V; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.245405 m2; ICAT-Volum: 0.0041013 m3
Name (ZYR_03.06.04.01 Reixa Paret Sobrepressio:RS01_V:...) | In | Group
358681 | P04 - SECTORITZACIÓ I EVACUACIÓ | ASP 2
362103 | PS1 - SECTORITZACIÓ I EVACUACIÓ | ASP 1
759211 | P00 - SECTORITZACIÓ I EVACUACIÓ | ASP 1
759311 | P05 - SECTORITZACIÓ I EVACUACIÓ | ASP 2
759315 | P03 - SECTORITZACIÓ I EVACUACIÓ | ASP 2
759319 | P02 - SECTORITZACIÓ I EVACUACIÓ | ASP 2
759323 | Nivel 1 | ASP 2
759327 | P0A - SECTORITZACIÓ I EVACUACIÓ | ASP 2

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Sostre Retorn:RR01_H (38)
Type - Material: Relleno, <Unnamed>
Classification: 50.30.50.50 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RR01_H; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RR01_H; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.044005 m2; ICAT-Volum: 0.0005773 m3
Name (ZYR_03.06.04.01 Reixa Sostre Retorn:RR01_H:...) | In | Group
476743 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 31
478639 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 13
478822 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 33
479135 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 14
490979 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 19
492911 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 8
493344 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 12
493372 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 11
493382 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 10
494326 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 8
500496 | Nivel 1 | Mecánica Aire de retorno 20
500519 | Nivel 1 | Mecánica Aire de retorno 9
501007 | Nivel 1 | Mecánica Aire de retorno 34
501015 | Nivel 1 | Mecánica Aire de retorno 36
501023 | Nivel 1 | Mecánica Aire de retorno 35
501035 | Nivel 1 | Mecánica Aire de retorno 38
501043 | Nivel 1 | Mecánica Aire de retorno 37
501053 | Nivel 1 | Mecánica Aire de retorno 40
501059 | Nivel 1 | Mecánica Aire de retorno 39
501069 | Nivel 1 | Mecánica Aire de retorno 41
503894 | Nivel 1 | Mecánica Aire de retorno 64
503916 | Nivel 1 | Mecánica Aire de retorno 63
504116 | Nivel 1 | Mecánica Aire de retorno 62
504499 | Nivel 1 | Mecánica Aire de retorno 61
504777 | Nivel 1 | Mecánica Aire de retorno 43
507196 | P05 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 53
507368 | P05 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 29
508318 | P05 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 27
508573 | P05 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 30
514383 | P0A - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 3
515922 | P0A - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 3
518410 | P00 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 55
518578 | P00 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 55
518597 | P00 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 55
757089 | P04 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 42
757138 | P04 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 23
757150 | P04 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 22
757668 | P04 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 21

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Sostre Retorn:RR02_H (6)
Type - Material: Relleno, <Unnamed>
Classification: 50.30.50.50 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RR02_H; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RR02_H; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.077805 m2; ICAT-Volum: 0.0010853 m3
Name (ZYR_03.06.04.01 Reixa Sostre Retorn:RR02_H:...) | In | Group
479501 | P03 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 15
491670 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 7
491907 | P02 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 8
508749 | P05 - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 54
514975 | P0A - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 5
515158 | P0A - SECTORITZACIÓ I EVACUACIÓ | Mecánica Aire de retorno 5

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Sostre Retorn:RR03_H (6)
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: Relleno, <Unnamed>
Classification: 50.30.50.50 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RR03_H; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RR03_H; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.097805 m2; ICAT-Volum: 0.0014853 m3
Name (ZYR_03.06.04.01 Reixa Sostre Retorn:RR03_H:...) | Group
513753 | Mecánica Aire de retorno 4
514706 | Mecánica Aire de retorno 4
514889 | Mecánica Aire de retorno 28
514896 | Mecánica Aire de retorno 28
515454 | Mecánica Aire de retorno 1
515602 | Mecánica Aire de retorno 1

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Sostre Sobrepressio:RI01_H (2)
Type - Material: Relleno, <Unnamed>
Classification: 50.30.50.50 (Uniformat); Group: ASP 5
Pset_DistributionFlowElementCommon - Reference: RI01_H; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RI01_H; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.138365 m2; ICAT-Volum: 0.0020949 m3
Name (ZYR_03.06.04.01 Reixa Sostre Sobrepressio:RI01_H:...) | In
758655 | PS1 - SECTORITZACIÓ I EVACUACIÓ
758786 | PS2 - SECTORITZACIÓ I EVACUACIÓ

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Sostre Sobrepressio:RS01_H (2)
Type - Material: Relleno, <Unnamed>
Classification: 50.30.50.50 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RS01_H; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RS01_H; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.245405 m2; ICAT-Volum: 0.0041013 m3
Name (ZYR_03.06.04.01 Reixa Sostre Sobrepressio:RS01_H:...) | In | Group
395506 | P00 - SECTORITZACIÓ I EVACUACIÓ | ASP 2
397421 | PS2 - SECTORITZACIÓ I EVACUACIÓ | ASP 1

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Sostre Sobrepressio:RS02 (2)
Type - Material: Relleno, <Unnamed>
Classification: 50.30.50.50 (Uniformat); Group: ASP 1
Pset_DistributionFlowElementCommon - Reference: RS02; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RS02; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.094705 m2; ICAT-Volum: 0.0013393 m3
Name (ZYR_03.06.04.01 Reixa Sostre Sobrepressio:RS02:...) | In
364068 | PS1 - SECTORITZACIÓ I EVACUACIÓ
383372 | PS2 - SECTORITZACIÓ I EVACUACIÓ

# IfcFlowTerminal: ZYR_03.06.04.01 Reixa Sostre Sobrepressio:RS04 (2)
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: Relleno, <Unnamed>
Classification: 50.30.50.50 (Uniformat); Group: ASP 5
Pset_DistributionFlowElementCommon - Reference: RS04; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: RS04; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.319205 m2; ICAT-Volum: 0.0054093 m3
Name (ZYR_03.06.04.01 Reixa Sostre Sobrepressio:RS04:...)
405942
406119

# IfcFlowTerminal: ZYR_03.06.08.01 Difusor Rotacional Circular Impulsió NO PLENUM:DC01 (10)
Type - Material: <Unnamed>
Classification: 50.30.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: DC01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: DC01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0972002 m2; ICAT-Volum: 0.000451415 m3
Name (ZYR_03.06.08.01 Difusor Rotacional Circular Impulsió NO PLENUM:DC01:...) | In | Group
356611 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 13
356632 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 14
356642 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 15
356805 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 17
356828 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 16
484694 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
497981 | Nivel 1 | AI 19
509323 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
509335 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
509343 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22

# IfcFlowTerminal: ZYR_03.06.08.01 Difusor Rotacional Circular Impulsió NO PLENUM:DC02 (79)
Type - Material: <Unnamed>
Classification: 50.30.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: DC02; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: DC02; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.141506 m2; ICAT-Volum: 0.000690436 m3
Name (ZYR_03.06.08.01 Difusor Rotacional Circular Impulsió NO PLENUM:DC02:...) | In | Group
354825 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 2
355793 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 4
355803 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 3
355901 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 5
355909 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 6
355940 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 9
355941 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 10
355942 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 8
355943 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 7
355967 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 11
356420 | P04 - SECTORITZACIÓ I EVACUACIÓ | AI 12
473130 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
473877 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
473885 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
474633 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
474886 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
474905 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
475125 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
475153 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
475163 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
479947 | P03 - SECTORITZACIÓ I EVACUACIÓ | AI 23
484248 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
484406 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
484422 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
484701 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
484710 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
485181 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
485518 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
486241 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
490344 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
490371 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
490707 | P02 - SECTORITZACIÓ I EVACUACIÓ | AI 21
496556 | Nivel 1 | AI 19
496563 | Nivel 1 | AI 19
496575 | Nivel 1 | AI 19
496793 | Nivel 1 | AI 19
496977 | Nivel 1 | AI 19
496989 | Nivel 1 | AI 19
496999 | Nivel 1 | AI 19
497500 | Nivel 1 | AI 19
504973 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18
505027 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18
505037 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18
505045 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18
505131 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18
505151 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18
505161 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18
505171 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18
505946 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18
506122 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18
506154 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18
506354 | P05 - SECTORITZACIÓ I EVACUACIÓ | AI 18
509287 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
509817 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
509923 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
509938 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
510562 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
510586 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
510587 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
510597 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
510598 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
512062 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
512073 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
512080 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
512757 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
512765 | P0A - SECTORITZACIÓ I EVACUACIÓ | AI 22
516388 | P00 - SECTORITZACIÓ I EVACUACIÓ | AI 24
516460 | P00 - SECTORITZACIÓ I EVACUACIÓ | AI 24
516483 | P00 - SECTORITZACIÓ I EVACUACIÓ | AI 24
516506 | P00 - SECTORITZACIÓ I EVACUACIÓ | AI 24
516507 | P00 - SECTORITZACIÓ I EVACUACIÓ | AI 24
516508 | P00 - SECTORITZACIÓ I EVACUACIÓ | AI 24
516516 | P00 - SECTORITZACIÓ I EVACUACIÓ | AI 24
516517 | P00 - SECTORITZACIÓ I EVACUACIÓ | AI 24
516518 | P00 - SECTORITZACIÓ I EVACUACIÓ | AI 24
516536 | P00 - SECTORITZACIÓ I EVACUACIÓ | AI 24
517491 | P00 - SECTORITZACIÓ I EVACUACIÓ | AI 24
517717 | P00 - SECTORITZACIÓ I EVACUACIÓ | AI 24
517953 | P00 - SECTORITZACIÓ I EVACUACIÓ | AI 24

# IfcFlowTerminal: ZYR_06.02.01 Pantalla 60X60:L05 (6)
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>, Vidrio
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L05; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L05; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.786 m2; ICAT-Volum: 0.0198 m3
Name (ZYR_06.02.01 Pantalla 60X60:L05:...)
656543
658665
658700
658701
659116
659215

# IfcFlowTerminal: ZYR_06.02.02 Down Superficie:L 01 (56)
Type - Material: <Unnamed>, Vidrio
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0151346 m2; ICAT-Volum: 0.000267642 m3
Name (ZYR_06.02.02 Down Superficie:L 01:...) | In
342232 | P04 - SECTORITZACIÓ I EVACUACIÓ
342242 | P04 - SECTORITZACIÓ I EVACUACIÓ
342312 | P04 - SECTORITZACIÓ I EVACUACIÓ
342320 | P04 - SECTORITZACIÓ I EVACUACIÓ
342330 | P04 - SECTORITZACIÓ I EVACUACIÓ
342338 | P04 - SECTORITZACIÓ I EVACUACIÓ
342357 | P04 - SECTORITZACIÓ I EVACUACIÓ
413669 | P03 - SECTORITZACIÓ I EVACUACIÓ
413670 | P03 - SECTORITZACIÓ I EVACUACIÓ
413671 | P03 - SECTORITZACIÓ I EVACUACIÓ
413672 | P03 - SECTORITZACIÓ I EVACUACIÓ
413673 | P03 - SECTORITZACIÓ I EVACUACIÓ
413686 | P03 - SECTORITZACIÓ I EVACUACIÓ
413702 | P03 - SECTORITZACIÓ I EVACUACIÓ
415062 | P02 - SECTORITZACIÓ I EVACUACIÓ
415063 | P02 - SECTORITZACIÓ I EVACUACIÓ
415064 | P02 - SECTORITZACIÓ I EVACUACIÓ
415065 | P02 - SECTORITZACIÓ I EVACUACIÓ
415066 | P02 - SECTORITZACIÓ I EVACUACIÓ
415067 | P02 - SECTORITZACIÓ I EVACUACIÓ
415068 | P02 - SECTORITZACIÓ I EVACUACIÓ
419628 | P05 - SECTORITZACIÓ I EVACUACIÓ
419629 | P05 - SECTORITZACIÓ I EVACUACIÓ
419630 | P05 - SECTORITZACIÓ I EVACUACIÓ
419631 | P05 - SECTORITZACIÓ I EVACUACIÓ
419632 | P05 - SECTORITZACIÓ I EVACUACIÓ
419633 | P05 - SECTORITZACIÓ I EVACUACIÓ
419634 | P05 - SECTORITZACIÓ I EVACUACIÓ
420133 | Nivel 1
420134 | Nivel 1
420135 | Nivel 1
420136 | Nivel 1
420137 | Nivel 1
420138 | Nivel 1
420139 | Nivel 1
421001 | P0A - SECTORITZACIÓ I EVACUACIÓ
421002 | P0A - SECTORITZACIÓ I EVACUACIÓ
421003 | P0A - SECTORITZACIÓ I EVACUACIÓ
421004 | P0A - SECTORITZACIÓ I EVACUACIÓ
421006 | P0A - SECTORITZACIÓ I EVACUACIÓ
421007 | P0A - SECTORITZACIÓ I EVACUACIÓ
421057 | P0A - SECTORITZACIÓ I EVACUACIÓ
421058 | P0A - SECTORITZACIÓ I EVACUACIÓ
421092 | P0A - SECTORITZACIÓ I EVACUACIÓ
421093 | P0A - SECTORITZACIÓ I EVACUACIÓ
421108 | P0A - SECTORITZACIÓ I EVACUACIÓ
421116 | P0A - SECTORITZACIÓ I EVACUACIÓ
659609 | P00 - SECTORITZACIÓ I EVACUACIÓ
659610 | P00 - SECTORITZACIÓ I EVACUACIÓ
659611 | P00 - SECTORITZACIÓ I EVACUACIÓ
659612 | P00 - SECTORITZACIÓ I EVACUACIÓ
659613 | P00 - SECTORITZACIÓ I EVACUACIÓ
659614 | P00 - SECTORITZACIÓ I EVACUACIÓ
659615 | P00 - SECTORITZACIÓ I EVACUACIÓ
679531 | P00 - SECTORITZACIÓ I EVACUACIÓ
679532 | P00 - SECTORITZACIÓ I EVACUACIÓ

# IfcFlowTerminal: ZYR_06.02.02 Down Superficie:L 02 (75)
Type - Material: <Unnamed>, Vidrio
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 02; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 02; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0348696 m2; ICAT-Volum: 0.00095814 m3
Name (ZYR_06.02.02 Down Superficie:L 02:...) | In
342384 | P04 - SECTORITZACIÓ I EVACUACIÓ
342580 | P04 - SECTORITZACIÓ I EVACUACIÓ
342632 | P04 - SECTORITZACIÓ I EVACUACIÓ
342640 | P04 - SECTORITZACIÓ I EVACUACIÓ
345756 | P04 - SECTORITZACIÓ I EVACUACIÓ
345757 | P04 - SECTORITZACIÓ I EVACUACIÓ
345758 | P04 - SECTORITZACIÓ I EVACUACIÓ
394195 | P03 - SECTORITZACIÓ I EVACUACIÓ
394196 | P03 - SECTORITZACIÓ I EVACUACIÓ
394197 | P03 - SECTORITZACIÓ I EVACUACIÓ
394198 | P03 - SECTORITZACIÓ I EVACUACIÓ
394532 | P03 - SECTORITZACIÓ I EVACUACIÓ
394533 | P03 - SECTORITZACIÓ I EVACUACIÓ
394534 | P03 - SECTORITZACIÓ I EVACUACIÓ
415054 | P02 - SECTORITZACIÓ I EVACUACIÓ
415055 | P02 - SECTORITZACIÓ I EVACUACIÓ
415056 | P02 - SECTORITZACIÓ I EVACUACIÓ
415057 | P02 - SECTORITZACIÓ I EVACUACIÓ
419635 | P05 - SECTORITZACIÓ I EVACUACIÓ
419636 | P05 - SECTORITZACIÓ I EVACUACIÓ
419637 | P05 - SECTORITZACIÓ I EVACUACIÓ
419638 | P05 - SECTORITZACIÓ I EVACUACIÓ
419639 | P05 - SECTORITZACIÓ I EVACUACIÓ
419640 | P05 - SECTORITZACIÓ I EVACUACIÓ
419641 | P05 - SECTORITZACIÓ I EVACUACIÓ
420125 | Nivel 1
420126 | Nivel 1
420127 | Nivel 1
420128 | Nivel 1
420129 | Nivel 1
420131 | Nivel 1
420132 | Nivel 1
420733 | P04 - SECTORITZACIÓ I EVACUACIÓ
420979 | P03 - SECTORITZACIÓ I EVACUACIÓ
420989 | P02 - SECTORITZACIÓ I EVACUACIÓ
420991 | Nivel 1
420993 | P0A - SECTORITZACIÓ I EVACUACIÓ
420994 | P0A - SECTORITZACIÓ I EVACUACIÓ
420995 | P0A - SECTORITZACIÓ I EVACUACIÓ
420996 | P0A - SECTORITZACIÓ I EVACUACIÓ
420997 | P0A - SECTORITZACIÓ I EVACUACIÓ
420999 | P0A - SECTORITZACIÓ I EVACUACIÓ
421000 | P0A - SECTORITZACIÓ I EVACUACIÓ
421008 | P0A - SECTORITZACIÓ I EVACUACIÓ
421076 | P0A - SECTORITZACIÓ I EVACUACIÓ
421136 | P0A - SECTORITZACIÓ I EVACUACIÓ
421150 | P0A - SECTORITZACIÓ I EVACUACIÓ
595547 | P02 - SECTORITZACIÓ I EVACUACIÓ
595548 | P02 - SECTORITZACIÓ I EVACUACIÓ
595549 | P02 - SECTORITZACIÓ I EVACUACIÓ
659602 | P00 - SECTORITZACIÓ I EVACUACIÓ
659603 | P00 - SECTORITZACIÓ I EVACUACIÓ
659604 | P00 - SECTORITZACIÓ I EVACUACIÓ
659605 | P00 - SECTORITZACIÓ I EVACUACIÓ
659606 | P00 - SECTORITZACIÓ I EVACUACIÓ
659607 | P00 - SECTORITZACIÓ I EVACUACIÓ
659608 | P00 - SECTORITZACIÓ I EVACUACIÓ
659616 | P00 - SECTORITZACIÓ I EVACUACIÓ
660270 | P00 - SECTORITZACIÓ I EVACUACIÓ
660675 | P00 - SECTORITZACIÓ I EVACUACIÓ
660722 | P00 - SECTORITZACIÓ I EVACUACIÓ
660730 | P00 - SECTORITZACIÓ I EVACUACIÓ
660784 | P00 - SECTORITZACIÓ I EVACUACIÓ
660818 | P00 - SECTORITZACIÓ I EVACUACIÓ
660969 | P00 - SECTORITZACIÓ I EVACUACIÓ
679173 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679245 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679246 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679247 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679280 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679298 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679306 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679566 | P00 - SECTORITZACIÓ I EVACUACIÓ
679592 | P00 - SECTORITZACIÓ I EVACUACIÓ
681107 | P05 - SECTORITZACIÓ I EVACUACIÓ

# IfcFlowTerminal: ZYR_06.02.02 Down Superficie:L 03 (75)
Type - Material: <Unnamed>, Vidrio
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 03; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 03; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0442944 m2; ICAT-Volum: 0.00142936 m3
Name (ZYR_06.02.02 Down Superficie:L 03:...) | In
330275 | P04 - SECTORITZACIÓ I EVACUACIÓ
330283 | P04 - SECTORITZACIÓ I EVACUACIÓ
330316 | P04 - SECTORITZACIÓ I EVACUACIÓ
330326 | P04 - SECTORITZACIÓ I EVACUACIÓ
330341 | P04 - SECTORITZACIÓ I EVACUACIÓ
330718 | P04 - SECTORITZACIÓ I EVACUACIÓ
330732 | P04 - SECTORITZACIÓ I EVACUACIÓ
330742 | P04 - SECTORITZACIÓ I EVACUACIÓ
330752 | P04 - SECTORITZACIÓ I EVACUACIÓ
330760 | P04 - SECTORITZACIÓ I EVACUACIÓ
330788 | P04 - SECTORITZACIÓ I EVACUACIÓ
330820 | P04 - SECTORITZACIÓ I EVACUACIÓ
330828 | P04 - SECTORITZACIÓ I EVACUACIÓ
330840 | P04 - SECTORITZACIÓ I EVACUACIÓ
330850 | P04 - SECTORITZACIÓ I EVACUACIÓ
330858 | P04 - SECTORITZACIÓ I EVACUACIÓ
330870 | P04 - SECTORITZACIÓ I EVACUACIÓ
394140 | P03 - SECTORITZACIÓ I EVACUACIÓ
394159 | P03 - SECTORITZACIÓ I EVACUACIÓ
394175 | P03 - SECTORITZACIÓ I EVACUACIÓ
394187 | P03 - SECTORITZACIÓ I EVACUACIÓ
412520 | P03 - SECTORITZACIÓ I EVACUACIÓ
412632 | P03 - SECTORITZACIÓ I EVACUACIÓ
412640 | P03 - SECTORITZACIÓ I EVACUACIÓ
412683 | P03 - SECTORITZACIÓ I EVACUACIÓ
412684 | P03 - SECTORITZACIÓ I EVACUACIÓ
412972 | P03 - SECTORITZACIÓ I EVACUACIÓ
412982 | P03 - SECTORITZACIÓ I EVACUACIÓ
412990 | P03 - SECTORITZACIÓ I EVACUACIÓ
412991 | P03 - SECTORITZACIÓ I EVACUACIÓ
413721 | P02 - SECTORITZACIÓ I EVACUACIÓ
413733 | P02 - SECTORITZACIÓ I EVACUACIÓ
414187 | P02 - SECTORITZACIÓ I EVACUACIÓ
414188 | P02 - SECTORITZACIÓ I EVACUACIÓ
414189 | P02 - SECTORITZACIÓ I EVACUACIÓ
414190 | P02 - SECTORITZACIÓ I EVACUACIÓ
414865 | P02 - SECTORITZACIÓ I EVACUACIÓ
414901 | P02 - SECTORITZACIÓ I EVACUACIÓ
415590 | P02 - SECTORITZACIÓ I EVACUACIÓ
415622 | P02 - SECTORITZACIÓ I EVACUACIÓ
415785 | P02 - SECTORITZACIÓ I EVACUACIÓ
416666 | Nivel 1
416680 | Nivel 1
416696 | Nivel 1
416704 | Nivel 1
416714 | Nivel 1
416736 | Nivel 1
418139 | P02 - SECTORITZACIÓ I EVACUACIÓ
418149 | P02 - SECTORITZACIÓ I EVACUACIÓ
418203 | P02 - SECTORITZACIÓ I EVACUACIÓ
418251 | P02 - SECTORITZACIÓ I EVACUACIÓ
418281 | P02 - SECTORITZACIÓ I EVACUACIÓ
418599 | P05 - SECTORITZACIÓ I EVACUACIÓ
418600 | P05 - SECTORITZACIÓ I EVACUACIÓ
418601 | P05 - SECTORITZACIÓ I EVACUACIÓ
418609 | P05 - SECTORITZACIÓ I EVACUACIÓ
418610 | P05 - SECTORITZACIÓ I EVACUACIÓ
418611 | P05 - SECTORITZACIÓ I EVACUACIÓ
418612 | P05 - SECTORITZACIÓ I EVACUACIÓ
418615 | P05 - SECTORITZACIÓ I EVACUACIÓ
418619 | P05 - SECTORITZACIÓ I EVACUACIÓ
418620 | P05 - SECTORITZACIÓ I EVACUACIÓ
418621 | P05 - SECTORITZACIÓ I EVACUACIÓ
418622 | P05 - SECTORITZACIÓ I EVACUACIÓ
418623 | P05 - SECTORITZACIÓ I EVACUACIÓ
419209 | P05 - SECTORITZACIÓ I EVACUACIÓ
419966 | Nivel 1
420081 | Nivel 1
420089 | Nivel 1
420106 | Nivel 1
420107 | Nivel 1
680551 | P0A - SECTORITZACIÓ I EVACUACIÓ
680559 | P0A - SECTORITZACIÓ I EVACUACIÓ
680609 | P0A - SECTORITZACIÓ I EVACUACIÓ
680610 | P0A - SECTORITZACIÓ I EVACUACIÓ

# IfcFlowTerminal: ZYR_06.02.02 Down Superficie:L 03 D (90)
Type - Material: <Unnamed>, Vidrio
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 03 D; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 03 D; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0442944 m2; ICAT-Volum: 0.00142936 m3
Name (ZYR_06.02.02 Down Superficie:L 03 D:...) | In
326980 | P04 - SECTORITZACIÓ I EVACUACIÓ
330255 | P04 - SECTORITZACIÓ I EVACUACIÓ
330265 | P04 - SECTORITZACIÓ I EVACUACIÓ
330361 | P04 - SECTORITZACIÓ I EVACUACIÓ
330373 | P04 - SECTORITZACIÓ I EVACUACIÓ
330390 | P04 - SECTORITZACIÓ I EVACUACIÓ
330398 | P04 - SECTORITZACIÓ I EVACUACIÓ
330686 | P04 - SECTORITZACIÓ I EVACUACIÓ
330710 | P04 - SECTORITZACIÓ I EVACUACIÓ
330770 | P04 - SECTORITZACIÓ I EVACUACIÓ
330780 | P04 - SECTORITZACIÓ I EVACUACIÓ
330800 | P04 - SECTORITZACIÓ I EVACUACIÓ
330810 | P04 - SECTORITZACIÓ I EVACUACIÓ
330882 | P04 - SECTORITZACIÓ I EVACUACIÓ
330892 | P04 - SECTORITZACIÓ I EVACUACIÓ
331103 | P04 - SECTORITZACIÓ I EVACUACIÓ
331113 | P04 - SECTORITZACIÓ I EVACUACIÓ
331127 | P04 - SECTORITZACIÓ I EVACUACIÓ
331128 | P04 - SECTORITZACIÓ I EVACUACIÓ
409181 | P03 - SECTORITZACIÓ I EVACUACIÓ
409203 | P03 - SECTORITZACIÓ I EVACUACIÓ
409221 | P03 - SECTORITZACIÓ I EVACUACIÓ
412358 | P03 - SECTORITZACIÓ I EVACUACIÓ
412370 | P03 - SECTORITZACIÓ I EVACUACIÓ
412458 | P03 - SECTORITZACIÓ I EVACUACIÓ
413510 | P03 - SECTORITZACIÓ I EVACUACIÓ
413518 | P03 - SECTORITZACIÓ I EVACUACIÓ
413708 | P02 - SECTORITZACIÓ I EVACUACIÓ
413741 | P02 - SECTORITZACIÓ I EVACUACIÓ
413808 | P02 - SECTORITZACIÓ I EVACUACIÓ
413809 | P02 - SECTORITZACIÓ I EVACUACIÓ
413810 | P02 - SECTORITZACIÓ I EVACUACIÓ
413811 | P02 - SECTORITZACIÓ I EVACUACIÓ
414153 | P02 - SECTORITZACIÓ I EVACUACIÓ
414163 | P02 - SECTORITZACIÓ I EVACUACIÓ
415359 | P02 - SECTORITZACIÓ I EVACUACIÓ
415367 | P02 - SECTORITZACIÓ I EVACUACIÓ
415375 | P02 - SECTORITZACIÓ I EVACUACIÓ
416648 | Nivel 1
416748 | Nivel 1
417117 | P02 - SECTORITZACIÓ I EVACUACIÓ
417125 | P02 - SECTORITZACIÓ I EVACUACIÓ
417794 | P02 - SECTORITZACIÓ I EVACUACIÓ
417795 | P02 - SECTORITZACIÓ I EVACUACIÓ
417945 | P02 - SECTORITZACIÓ I EVACUACIÓ
417946 | P02 - SECTORITZACIÓ I EVACUACIÓ
418003 | P02 - SECTORITZACIÓ I EVACUACIÓ
418004 | P02 - SECTORITZACIÓ I EVACUACIÓ
418072 | P02 - SECTORITZACIÓ I EVACUACIÓ
418073 | P02 - SECTORITZACIÓ I EVACUACIÓ
418333 | P02 - SECTORITZACIÓ I EVACUACIÓ
418377 | P03 - SECTORITZACIÓ I EVACUACIÓ
418378 | P03 - SECTORITZACIÓ I EVACUACIÓ
418379 | P03 - SECTORITZACIÓ I EVACUACIÓ
418380 | P03 - SECTORITZACIÓ I EVACUACIÓ
418604 | P05 - SECTORITZACIÓ I EVACUACIÓ
418605 | P05 - SECTORITZACIÓ I EVACUACIÓ
418613 | P05 - SECTORITZACIÓ I EVACUACIÓ
418614 | P05 - SECTORITZACIÓ I EVACUACIÓ
418624 | P05 - SECTORITZACIÓ I EVACUACIÓ
418625 | P05 - SECTORITZACIÓ I EVACUACIÓ
419319 | P05 - SECTORITZACIÓ I EVACUACIÓ
419327 | P05 - SECTORITZACIÓ I EVACUACIÓ
