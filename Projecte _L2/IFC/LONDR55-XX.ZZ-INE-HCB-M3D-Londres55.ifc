Properties of the parts of a building model (IFC2X3), part 9 of 9

# IfcFlowTerminal: ZYR_06.02.02 Down Superficie:L 03 D (90)
Name (ZYR_06.02.02 Down Superficie:L 03 D:...) | In
419617 | P05 - SECTORITZACIÓ I EVACUACIÓ
419618 | P05 - SECTORITZACIÓ I EVACUACIÓ
419619 | P05 - SECTORITZACIÓ I EVACUACIÓ
419620 | P05 - SECTORITZACIÓ I EVACUACIÓ
419959 | Nivel 1
419960 | Nivel 1
419967 | Nivel 1
419974 | Nivel 1
419975 | Nivel 1
420123 | Nivel 1
420124 | Nivel 1
420147 | Nivel 1
420155 | Nivel 1
420163 | Nivel 1
420171 | Nivel 1
420192 | Nivel 1
420200 | Nivel 1
420379 | Nivel 1
420387 | Nivel 1
658494 | P05 - SECTORITZACIÓ I EVACUACIÓ
658502 | P05 - SECTORITZACIÓ I EVACUACIÓ
658519 | P05 - SECTORITZACIÓ I EVACUACIÓ
658520 | P05 - SECTORITZACIÓ I EVACUACIÓ
658583 | P05 - SECTORITZACIÓ I EVACUACIÓ
658584 | P05 - SECTORITZACIÓ I EVACUACIÓ
658592 | P05 - SECTORITZACIÓ I EVACUACIÓ
658593 | P05 - SECTORITZACIÓ I EVACUACIÓ

# IfcFlowTerminal: ZYR_06.02.02 Down Superficie:L 04 D (8)
Type - Material: <Unnamed>, Vidrio
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 04 D; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 04 D; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0348696 m2; ICAT-Volum: 0.00095814 m3
Name (ZYR_06.02.02 Down Superficie:L 04 D:...) | In
412315 | P03 - SECTORITZACIÓ I EVACUACIÓ
412393 | P03 - SECTORITZACIÓ I EVACUACIÓ
412444 | P03 - SECTORITZACIÓ I EVACUACIÓ
413542 | P03 - SECTORITZACIÓ I EVACUACIÓ
414036 | P02 - SECTORITZACIÓ I EVACUACIÓ
415345 | P02 - SECTORITZACIÓ I EVACUACIÓ
416405 | Nivel 1
420121 | Nivel 1

# IfcFlowTerminal: ZYR_06.02.03 Aplic Circular 2:L 07 (35)
Type - Material: BLANC, Vidrio
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 07; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 07; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0850521 m2; ICAT-Volum: 0.00094636 m3
Name (ZYR_06.02.03 Aplic Circular 2:L 07:...) | In
345587 | P04 - SECTORITZACIÓ I EVACUACIÓ
345627 | P04 - SECTORITZACIÓ I EVACUACIÓ
345635 | P04 - SECTORITZACIÓ I EVACUACIÓ
345653 | P04 - SECTORITZACIÓ I EVACUACIÓ
422597 | P03 - SECTORITZACIÓ I EVACUACIÓ
422598 | P03 - SECTORITZACIÓ I EVACUACIÓ
422599 | P03 - SECTORITZACIÓ I EVACUACIÓ
422600 | P03 - SECTORITZACIÓ I EVACUACIÓ
422602 | P02 - SECTORITZACIÓ I EVACUACIÓ
422603 | P02 - SECTORITZACIÓ I EVACUACIÓ
422604 | P02 - SECTORITZACIÓ I EVACUACIÓ
422605 | P02 - SECTORITZACIÓ I EVACUACIÓ
422607 | Nivel 1
422608 | Nivel 1
422609 | Nivel 1
422610 | Nivel 1
422612 | P0A - SECTORITZACIÓ I EVACUACIÓ
422613 | P0A - SECTORITZACIÓ I EVACUACIÓ
422614 | P0A - SECTORITZACIÓ I EVACUACIÓ
422615 | P0A - SECTORITZACIÓ I EVACUACIÓ
422617 | P05 - SECTORITZACIÓ I EVACUACIÓ
422618 | P05 - SECTORITZACIÓ I EVACUACIÓ
422619 | P05 - SECTORITZACIÓ I EVACUACIÓ
422620 | P05 - SECTORITZACIÓ I EVACUACIÓ
422622 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
422623 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
422624 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
422625 | PsotaC - SECTORITZACIÓ I EVACUACIÓ
659617 | P00 - SECTORITZACIÓ I EVACUACIÓ
659618 | P00 - SECTORITZACIÓ I EVACUACIÓ
659620 | P00 - SECTORITZACIÓ I EVACUACIÓ
679174 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679175 | PS1 - SECTORITZACIÓ I EVACUACIÓ
679176 | P00 - SECTORITZACIÓ I EVACUACIÓ
679177 | PS1 - SECTORITZACIÓ I EVACUACIÓ

# IfcFlowTerminal: ZYR_06.02.03 Aplic Exterior:Aplic Exterior Tipus 01 (2)
In: Nivel 1
Type - Material: BLANC, Vidrio
Classification: 50.60.50.10 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Aplic Exterior Tipus 01; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Aplic Exterior Tipus 01; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.190088 m2; ICAT-Volum: 0.00295602 m3
Name (ZYR_06.02.03 Aplic Exterior:Aplic Exterior Tipus 01:...)
651243
651315

# IfcFlowTerminal: ZYR_06.02.05 LLuminaria Lineal Encastada:L08 (12)
In: PS1 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, Vidrio
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L08; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L08; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.6243 m2; ICAT-Volum: 0.02295 m3
Name (ZYR_06.02.05 LLuminaria Lineal Encastada:L08:...)
678451
678504
678538
678548
678577
678578
678579
678580
678597
678598
678599
678600

# IfcFlowTerminal: ZYR_06.02.05 LLuminaria Lineal Superficie:L06, ZYR_06.02.05 LLuminaria Lineal Superficie:L06:684280
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: BLANC, Vidrio
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L06; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L06; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.917771 m2; ICAT-Volum: 0.033936 m3

# IfcFlowTerminal: ZYR_06.02.05 LLuminària Suspesa:L 12 (41)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 12; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 12; ICAT_04-EstatusObra: Nueva construcción
Name (ZYR_06.02.05 LLuminària Suspesa:L 12:...) | In | ICAT-Superficie (m2) | ICAT-Volum (m3)
341729 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.313649 | 0.0115136
341884 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.313649 | 0.0115136
414207 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.313649 | 0.0115136
414675 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.313649 | 0.0115136
414738 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.313649 | 0.0115136
414739 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.313649 | 0.0115136
414937 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.313649 | 0.0115136
414938 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.313649 | 0.0115136
415664 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.313649 | 0.0115136
416231 | Nivel 1 | 0.313649 | 0.0115136
416232 | Nivel 1 | 0.313649 | 0.0115136
416240 | Nivel 1 | 0.313649 | 0.0115136
416241 | Nivel 1 | 0.313649 | 0.0115136
416253 | Nivel 1 | 0.313649 | 0.0115136
416254 | Nivel 1 | 0.313649 | 0.0115136
416266 | Nivel 1 | 0.313649 | 0.0115136
416267 | Nivel 1 | 0.313649 | 0.0115136
416311 | Nivel 1 | 0.313649 | 0.0115136
416312 | Nivel 1 | 0.313649 | 0.0115136
416320 | Nivel 1 | 0.313649 | 0.0115136
416321 | Nivel 1 | 0.313649 | 0.0115136
416331 | Nivel 1 | 0.313649 | 0.0115136
416332 | Nivel 1 | 0.313649 | 0.0115136
416344 | Nivel 1 | 0.313649 | 0.0115136
416345 | Nivel 1 | 0.313649 | 0.0115136
416764 | Nivel 1 | 0.313649 | 0.0115136
416783 | Nivel 1 | 0.313649 | 0.0115136
416804 | Nivel 1 | 0.313649 | 0.0115136
416805 | Nivel 1 | 0.313649 | 0.0115136
416878 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.313649 | 0.0115136
419655 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.313649 | 0.0115136
680337 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.305921 | 0.0114363
680370 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.305921 | 0.0114363
680417 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.305921 | 0.0114363
680418 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.305921 | 0.0114363
680436 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.305921 | 0.0114363
680437 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.305921 | 0.0114363
680445 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.305921 | 0.0114363
680446 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.305921 | 0.0114363
700403 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.305921 | 0.0114363
700413 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.305921 | 0.0114363

# IfcFlowTerminal: ZYR_06.02.05 LLuminària Suspesa:L 12 D (25)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 12 D; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 12 D; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.313649 m2; ICAT-Volum: 0.0115136 m3
Name (ZYR_06.02.05 LLuminària Suspesa:L 12 D:...) | In
341862 | P04 - SECTORITZACIÓ I EVACUACIÓ
394579 | P03 - SECTORITZACIÓ I EVACUACIÓ
409118 | P03 - SECTORITZACIÓ I EVACUACIÓ
412342 | P03 - SECTORITZACIÓ I EVACUACIÓ
412412 | P03 - SECTORITZACIÓ I EVACUACIÓ
413389 | P03 - SECTORITZACIÓ I EVACUACIÓ
413597 | P03 - SECTORITZACIÓ I EVACUACIÓ
413603 | P03 - SECTORITZACIÓ I EVACUACIÓ
413620 | P03 - SECTORITZACIÓ I EVACUACIÓ
413621 | P03 - SECTORITZACIÓ I EVACUACIÓ
413622 | P03 - SECTORITZACIÓ I EVACUACIÓ
414124 | P02 - SECTORITZACIÓ I EVACUACIÓ
415303 | P02 - SECTORITZACIÓ I EVACUACIÓ
416173 | Nivel 1
416206 | Nivel 1
416377 | Nivel 1
419406 | P05 - SECTORITZACIÓ I EVACUACIÓ
419556 | P05 - SECTORITZACIÓ I EVACUACIÓ
419735 | P05 - SECTORITZACIÓ I EVACUACIÓ
420122 | Nivel 1
420560 | Nivel 1
420602 | Nivel 1
420623 | Nivel 1
420624 | Nivel 1
658548 | P05 - SECTORITZACIÓ I EVACUACIÓ

# IfcFlowTerminal: ZYR_06.02.05 LLuminària Suspesa:L 12 E (6)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 12 E; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 12 E; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.313649 m2; ICAT-Volum: 0.0115136 m3
Name (ZYR_06.02.05 LLuminària Suspesa:L 12 E:...) | In
412750 | P03 - SECTORITZACIÓ I EVACUACIÓ
416982 | P02 - SECTORITZACIÓ I EVACUACIÓ
417054 | P02 - SECTORITZACIÓ I EVACUACIÓ
418643 | P05 - SECTORITZACIÓ I EVACUACIÓ
419972 | Nivel 1
419973 | Nivel 1

# IfcFlowTerminal: ZYR_06.02.05 LLuminària Suspesa:L 12 ED (8)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 12 ED; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 12 ED; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.313649 m2; ICAT-Volum: 0.0115136 m3
Name (ZYR_06.02.05 LLuminària Suspesa:L 12 ED:...) | In
341027 | P04 - SECTORITZACIÓ I EVACUACIÓ
341074 | P04 - SECTORITZACIÓ I EVACUACIÓ
341113 | P04 - SECTORITZACIÓ I EVACUACIÓ
341114 | P04 - SECTORITZACIÓ I EVACUACIÓ
418639 | P05 - SECTORITZACIÓ I EVACUACIÓ
418640 | P05 - SECTORITZACIÓ I EVACUACIÓ
418649 | P05 - SECTORITZACIÓ I EVACUACIÓ
418650 | P05 - SECTORITZACIÓ I EVACUACIÓ

# IfcFlowTerminal: ZYR_06.02.05 LLuminària Suspesa:L 13 D (2)
In: P05 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 13 D; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 13 D; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.360409 m2; ICAT-Volum: 0.0133896 m3
Name (ZYR_06.02.05 LLuminària Suspesa:L 13 D:...)
419405
658547

# IfcFlowTerminal: ZYR_06.02.05 LLuminària Suspesa:L 13 E (10)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 13 E; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 13 E; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.360409 m2; ICAT-Volum: 0.0133896 m3
Name (ZYR_06.02.05 LLuminària Suspesa:L 13 E:...) | In
330174 | P04 - SECTORITZACIÓ I EVACUACIÓ
416153 | P02 - SECTORITZACIÓ I EVACUACIÓ
417359 | P02 - SECTORITZACIÓ I EVACUACIÓ
417360 | P02 - SECTORITZACIÓ I EVACUACIÓ
417382 | P02 - SECTORITZACIÓ I EVACUACIÓ
417417 | P02 - SECTORITZACIÓ I EVACUACIÓ
420025 | Nivel 1
420026 | Nivel 1
420044 | Nivel 1
420045 | Nivel 1

# IfcFlowTerminal: ZYR_06.02.05 LLuminària Suspesa:L 13 ED (2)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 13 ED; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 13 ED; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.360409 m2; ICAT-Volum: 0.0133896 m3
Name (ZYR_06.02.05 LLuminària Suspesa:L 13 ED:...) | In
340832 | P04 - SECTORITZACIÓ I EVACUACIÓ
418630 | P05 - SECTORITZACIÓ I EVACUACIÓ

# IfcFlowTerminal: ZYR_06.02.05 LLuminària Suspesa:L 14 (9)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 14; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 14; ICAT_04-EstatusObra: Nueva construcción
Name (ZYR_06.02.05 LLuminària Suspesa:L 14:...) | In | ICAT-Superficie (m2) | ICAT-Volum (m3)
341904 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.453929 | 0.0171416
412840 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.453929 | 0.0171416
414191 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.453929 | 0.0171416
419621 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.453929 | 0.0171416
680515 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.446201 | 0.0170643
680696 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.446201 | 0.0170643
680716 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.446201 | 0.0170643
680733 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.446201 | 0.0170643
680734 | P0A - SECTORITZACIÓ I EVACUACIÓ | 0.446201 | 0.0170643

# IfcFlowTerminal: ZYR_06.02.05 LLuminària Suspesa:L 14 D, ZYR_06.02.05 LLuminària Suspesa:L 14 D:419557
In: P05 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 14 D; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 14 D; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.453929 m2; ICAT-Volum: 0.0171416 m3

# IfcFlowTerminal: ZYR_06.02.05 LLuminària Suspesa:L 14 E (44)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 14 E; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 14 E; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.453929 m2; ICAT-Volum: 0.0171416 m3
Name (ZYR_06.02.05 LLuminària Suspesa:L 14 E:...) | In
340798 | P04 - SECTORITZACIÓ I EVACUACIÓ
340934 | P04 - SECTORITZACIÓ I EVACUACIÓ
340971 | P04 - SECTORITZACIÓ I EVACUACIÓ
340981 | P04 - SECTORITZACIÓ I EVACUACIÓ
340991 | P04 - SECTORITZACIÓ I EVACUACIÓ
341001 | P04 - SECTORITZACIÓ I EVACUACIÓ
341009 | P04 - SECTORITZACIÓ I EVACUACIÓ
341107 | P04 - SECTORITZACIÓ I EVACUACIÓ
341108 | P04 - SECTORITZACIÓ I EVACUACIÓ
341109 | P04 - SECTORITZACIÓ I EVACUACIÓ
341110 | P04 - SECTORITZACIÓ I EVACUACIÓ
341111 | P04 - SECTORITZACIÓ I EVACUACIÓ
341112 | P04 - SECTORITZACIÓ I EVACUACIÓ
381887 | P03 - SECTORITZACIÓ I EVACUACIÓ
382126 | P03 - SECTORITZACIÓ I EVACUACIÓ
394075 | P03 - SECTORITZACIÓ I EVACUACIÓ
394083 | P03 - SECTORITZACIÓ I EVACUACIÓ
394095 | P03 - SECTORITZACIÓ I EVACUACIÓ
394103 | P03 - SECTORITZACIÓ I EVACUACIÓ
394124 | P03 - SECTORITZACIÓ I EVACUACIÓ
394125 | P03 - SECTORITZACIÓ I EVACUACIÓ
394126 | P03 - SECTORITZACIÓ I EVACUACIÓ
394127 | P03 - SECTORITZACIÓ I EVACUACIÓ
394128 | P03 - SECTORITZACIÓ I EVACUACIÓ
394129 | P03 - SECTORITZACIÓ I EVACUACIÓ
412702 | P03 - SECTORITZACIÓ I EVACUACIÓ
412724 | P03 - SECTORITZACIÓ I EVACUACIÓ
416956 | P02 - SECTORITZACIÓ I EVACUACIÓ
416957 | P02 - SECTORITZACIÓ I EVACUACIÓ
418596 | P05 - SECTORITZACIÓ I EVACUACIÓ
418628 | P05 - SECTORITZACIÓ I EVACUACIÓ
418633 | P05 - SECTORITZACIÓ I EVACUACIÓ
418634 | P05 - SECTORITZACIÓ I EVACUACIÓ
418635 | P05 - SECTORITZACIÓ I EVACUACIÓ
418636 | P05 - SECTORITZACIÓ I EVACUACIÓ
418637 | P05 - SECTORITZACIÓ I EVACUACIÓ
418638 | P05 - SECTORITZACIÓ I EVACUACIÓ
418644 | P05 - SECTORITZACIÓ I EVACUACIÓ
418645 | P05 - SECTORITZACIÓ I EVACUACIÓ
418646 | P05 - SECTORITZACIÓ I EVACUACIÓ
418647 | P05 - SECTORITZACIÓ I EVACUACIÓ
418648 | P05 - SECTORITZACIÓ I EVACUACIÓ
419970 | Nivel 1
419971 | Nivel 1

# IfcFlowTerminal: ZYR_06.02.05 LLuminària Suspesa:L 14 ED (24)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L 14 ED; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L 14 ED; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.453929 m2; ICAT-Volum: 0.0171416 m3
Name (ZYR_06.02.05 LLuminària Suspesa:L 14 ED:...) | In
340337 | P04 - SECTORITZACIÓ I EVACUACIÓ
340747 | P04 - SECTORITZACIÓ I EVACUACIÓ
340822 | P04 - SECTORITZACIÓ I EVACUACIÓ
340886 | P04 - SECTORITZACIÓ I EVACUACIÓ
340910 | P04 - SECTORITZACIÓ I EVACUACIÓ
341105 | P04 - SECTORITZACIÓ I EVACUACIÓ
341106 | P04 - SECTORITZACIÓ I EVACUACIÓ
413753 | P02 - SECTORITZACIÓ I EVACUACIÓ
413776 | P02 - SECTORITZACIÓ I EVACUACIÓ
413812 | P02 - SECTORITZACIÓ I EVACUACIÓ
413813 | P02 - SECTORITZACIÓ I EVACUACIÓ
416924 | P02 - SECTORITZACIÓ I EVACUACIÓ
416925 | P02 - SECTORITZACIÓ I EVACUACIÓ
417532 | P02 - SECTORITZACIÓ I EVACUACIÓ
417533 | P02 - SECTORITZACIÓ I EVACUACIÓ
417555 | P02 - SECTORITZACIÓ I EVACUACIÓ
417730 | P02 - SECTORITZACIÓ I EVACUACIÓ
418381 | P03 - SECTORITZACIÓ I EVACUACIÓ
418382 | P03 - SECTORITZACIÓ I EVACUACIÓ
418629 | P05 - SECTORITZACIÓ I EVACUACIÓ
419963 | Nivel 1
419964 | Nivel 1
419968 | Nivel 1
419969 | Nivel 1

# IfcFlowTerminal: ZYR_06.02.05 LLuminària Suspesa:L09 (10)
In: P00 - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L09; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L09; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.244629 m2; ICAT-Volum: 0.0112524 m3
Name (ZYR_06.02.05 LLuminària Suspesa:L09:...)
672909
673048
673060
673070
673080
673090
673098
673106
673114
673122

# IfcFlowTerminal: ZYR_06.02.05 LLuminària Suspesa:L10 (8)
In: P0A - SECTORITZACIÓ I EVACUACIÓ
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L10; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: L10; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.329061 m2; ICAT-Volum: 0.0136203 m3
Name (ZYR_06.02.05 LLuminària Suspesa:L10:...)
680063
680169
680317
680318
680484
680485
680493
680494

# IfcFlowTerminal: ZYR_06.02.05 Tira Led:Tira Led 03 (66)
Type - Material: <Unnamed>
Classification: 50.60.50.20 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Tira Led 03; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Tira Led 03; ICAT_04-EstatusObra: Nueva construcción
Name (ZYR_06.02.05 Tira Led:Tira Led 03:...) | In | ICAT-Superficie (m2) | ICAT-Volum (m3)
637259 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
656862 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.140785 | 0.00452615
657092 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0694519 | 0.0021484
657588 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0787132 | 0.00245711
657771 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0787132 | 0.00245711
657961 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658008 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658059 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658117 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658160 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658209 | P04 - SECTORITZACIÓ I EVACUACIÓ | 0.0516673 | 0.00155558
658365 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658366 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.140785 | 0.00452615
658367 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0694519 | 0.0021484
658368 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0787132 | 0.00245711
658369 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0787132 | 0.00245711
658370 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658371 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658372 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658373 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658374 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658375 | P03 - SECTORITZACIÓ I EVACUACIÓ | 0.0516673 | 0.00155558
658377 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658378 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.140785 | 0.00452615
658379 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0694519 | 0.0021484
658380 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0787132 | 0.00245711
658381 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0787132 | 0.00245711
658382 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658383 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658384 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658385 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658386 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658387 | P02 - SECTORITZACIÓ I EVACUACIÓ | 0.0516673 | 0.00155558
658389 | Nivel 1 | 0.0899239 | 0.0028308
658390 | Nivel 1 | 0.140785 | 0.00452615
658391 | Nivel 1 | 0.0694519 | 0.0021484
658392 | Nivel 1 | 0.0787132 | 0.00245711
658393 | Nivel 1 | 0.0787132 | 0.00245711
658394 | Nivel 1 | 0.0899239 | 0.0028308
658395 | Nivel 1 | 0.0899239 | 0.0028308
658396 | Nivel 1 | 0.0899239 | 0.0028308
658397 | Nivel 1 | 0.0899239 | 0.0028308
658398 | Nivel 1 | 0.0899239 | 0.0028308
658399 | Nivel 1 | 0.0516673 | 0.00155558
658401 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658402 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.140785 | 0.00452615
658403 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0694519 | 0.0021484
658404 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0787132 | 0.00245711
658405 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0787132 | 0.00245711
658406 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658407 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658408 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658409 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658410 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658411 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0516673 | 0.00155558
658413 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658414 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.140785 | 0.00452615
658415 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0694519 | 0.0021484
658416 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0787132 | 0.00245711
658417 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0787132 | 0.00245711
658418 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658419 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658420 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658421 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658422 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0899239 | 0.0028308
658423 | P05 - SECTORITZACIÓ I EVACUACIÓ | 0.0516673 | 0.00155558

# IfcFlowTerminal: ZYR_13.01 CON_AF_SAN_VERT:Lavabo (2)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Lavabo; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Lavabo; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.00378935 m2; ICAT-Volum: 0.0000412314 m3
Name (ZYR_13.01 CON_AF_SAN_VERT:Lavabo:...) | In | Group
689531 | P00 - SECTORITZACIÓ I EVACUACIÓ | AFS 3; SAN_Fecal Enterrat 1
690334 | P0A - SECTORITZACIÓ I EVACUACIÓ | AFS 2

# IfcFlowTerminal: ZYR_13.01 CON_AF_SAN_VERT:Water (4)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Water; sets with these values: 2
ICAT-Identificacio - ICAT_03-Tipus: Water; ICAT_04-EstatusObra: Nueva construcción
ICAT-Geometria - ICAT-Superficie: 0.0153336 m2; ICAT-Volum: 0.00028862 m3
Name (ZYR_13.01 CON_AF_SAN_VERT:Water:...) | In | Group
689288 | P00 - SECTORITZACIÓ I EVACUACIÓ | AFS 3; SAN_Fecal Enterrat 1
690047 | P00 - SECTORITZACIÓ I EVACUACIÓ | AFS 1; SAN_Fecal Enterrat 1
690333 | P0A - SECTORITZACIÓ I EVACUACIÓ | SAN_Fecal Aeri 1; AFS 2
793777 | P0A - SECTORITZACIÓ I EVACUACIÓ | AFS 4; SAN_Fecal Aeri 2
